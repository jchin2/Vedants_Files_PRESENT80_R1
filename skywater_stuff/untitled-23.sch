v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N -47.5 -270 10 -270 { lab=k0}
N -47.5 -290 10 -290 { lab=x0_bar}
N -47.5 -310 10 -310 { lab=x0}
N -47.5 -210 10 -210 { lab=x1_bar}
N -47.5 -230 10 -230 { lab=x1}
N -47.5 -250 10 -250 { lab=k0_bar}
N -47.5 -150 10 -150 { lab=x2}
N -47.5 -170 10 -170 { lab=k1_bar}
N -47.5 -190 10 -190 { lab=k1}
N -47.5 -90 10 -90 { lab=k2_bar}
N -47.5 -110 10 -110 { lab=k2}
N -47.5 -130 10 -130 { lab=x2_bar}
N -47.5 -30 10 -30 { lab=k3}
N -47.5 -50 10 -50 { lab=x3_bar}
N -47.5 -70 10 -70 { lab=x3}
N -47.5 -10 10 -10 { lab=k3_bar}
N -47.5 -330 10 -330 { lab=VDD}
N 310 -330 350 -330 { lab=s0}
N 310 -310 350 -310 { lab=s1}
N 310 -290 350 -290 { lab=s2}
N 310 -270 350 -270 { lab=s3}
N -47.5 120 10 120 { lab=k4}
N -47.5 100 10 100 { lab=x4_bar}
N -47.5 80 10 80 { lab=x4}
N -47.5 180 10 180 { lab=x5_bar}
N -47.5 160 10 160 { lab=x5}
N -47.5 140 10 140 { lab=k4_bar}
N -47.5 240 10 240 { lab=x6}
N -47.5 220 10 220 { lab=k5_bar}
N -47.5 200 10 200 { lab=k5}
N -47.5 300 10 300 { lab=k6_bar}
N -47.5 280 10 280 { lab=k6}
N -47.5 260 10 260 { lab=x6_bar}
N -47.5 360 10 360 { lab=k7}
N -47.5 340 10 340 { lab=x7_bar}
N -47.5 320 10 320 { lab=x7}
N -47.5 380 10 380 { lab=k7_bar}
N -47.5 60 10 60 { lab=#net1}
N 310 60 350 60 { lab=s4}
N 310 80 350 80 { lab=s5}
N 310 100 350 100 { lab=s6}
N 310 120 350 120 { lab=s7}
N -47.5 503 10 503 { lab=k8}
N -47.5 483 10 483 { lab=x8_bar}
N -47.5 463 10 463 { lab=x8}
N -47.5 563 10 563 { lab=x9_bar}
N -47.5 543 10 543 { lab=x9}
N -47.5 523 10 523 { lab=k8_bar}
N -47.5 623 10 623 { lab=x10}
N -47.5 603 10 603 { lab=k9_bar}
N -47.5 583 10 583 { lab=k9}
N -47.5 683 10 683 { lab=k10_bar}
N -47.5 663 10 663 { lab=k10}
N -47.5 643 10 643 { lab=x10_bar}
N -47.5 743 10 743 { lab=k11}
N -47.5 723 10 723 { lab=x11_bar}
N -47.5 703 10 703 { lab=x11}
N -47.5 763 10 763 { lab=k11_bar}
N -47.5 443 10 443 { lab=#net2}
N 310 443 350 443 { lab=#net3}
N 310 463 350 463 { lab=#net4}
N 310 483 350 483 { lab=#net5}
N 310 503 350 503 { lab=#net6}
N -47.5 893 10 893 { lab=k12}
N -47.5 873 10 873 { lab=x12_bar}
N -47.5 853 10 853 { lab=x12}
N -47.5 953 10 953 { lab=x13_bar}
N -47.5 933 10 933 { lab=x13}
N -47.5 913 10 913 { lab=k12_bar}
N -47.5 1013 10 1013 { lab=x14}
N -47.5 993 10 993 { lab=k13_bar}
N -47.5 973 10 973 { lab=k13}
N -47.5 1073 10 1073 { lab=k14_bar}
N -47.5 1053 10 1053 { lab=k14}
N -47.5 1033 10 1033 { lab=x14_bar}
N -47.5 1133 10 1133 { lab=k15}
N -47.5 1113 10 1113 { lab=x15_bar}
N -47.5 1093 10 1093 { lab=x15}
N -47.5 1153 10 1153 { lab=k15_bar}
N -47.5 833 10 833 { lab=#net7}
N 310 833 350 833 { lab=#net8}
N 310 853 350 853 { lab=#net9}
N 310 873 350 873 { lab=#net10}
N 310 893 350 893 { lab=#net11}
N -47.5 1271 10 1271 { lab=k16}
N -47.5 1251 10 1251 { lab=x16_bar}
N -47.5 1231 10 1231 { lab=x16}
N -47.5 1331 10 1331 { lab=x17_bar}
N -47.5 1311 10 1311 { lab=x17}
N -47.5 1291 10 1291 { lab=k16_bar}
N -47.5 1391 10 1391 { lab=x18}
N -47.5 1371 10 1371 { lab=k17_bar}
N -47.5 1351 10 1351 { lab=k17}
N -47.5 1451 10 1451 { lab=k18_bar}
N -47.5 1431 10 1431 { lab=k18}
N -47.5 1411 10 1411 { lab=x18_bar}
N -47.5 1511 10 1511 { lab=k19}
N -47.5 1491 10 1491 { lab=x19_bar}
N -47.5 1471 10 1471 { lab=x19}
N -47.5 1531 10 1531 { lab=k19_bar}
N -47.5 1211 10 1211 { lab=#net12}
N 310 1211 350 1211 { lab=#net13}
N 310 1231 350 1231 { lab=#net14}
N 310 1251 350 1251 { lab=#net15}
N 310 1271 350 1271 { lab=#net16}
N -47.5 1661 10 1661 { lab=k20}
N -47.5 1641 10 1641 { lab=x20_bar}
N -47.5 1621 10 1621 { lab=x20}
N -47.5 1721 10 1721 { lab=x21_bar}
N -47.5 1701 10 1701 { lab=x21}
N -47.5 1681 10 1681 { lab=k20_bar}
N -47.5 1781 10 1781 { lab=x22}
N -47.5 1761 10 1761 { lab=k21_bar}
N -47.5 1741 10 1741 { lab=k21}
N -47.5 1841 10 1841 { lab=k22_bar}
N -47.5 1821 10 1821 { lab=k22}
N -47.5 1801 10 1801 { lab=x22_bar}
N -47.5 1901 10 1901 { lab=k23}
N -47.5 1881 10 1881 { lab=x23_bar}
N -47.5 1861 10 1861 { lab=x23}
N -47.5 1921 10 1921 { lab=k23_bar}
N -47.5 1601 10 1601 { lab=#net17}
N 310 1601 350 1601 { lab=#net18}
N 310 1621 350 1621 { lab=#net19}
N 310 1641 350 1641 { lab=#net20}
N 310 1661 350 1661 { lab=#net21}
N -47.5 2044 10 2044 { lab=k24}
N -47.5 2024 10 2024 { lab=x24_bar}
N -47.5 2004 10 2004 { lab=x24}
N -47.5 2104 10 2104 { lab=x25_bar}
N -47.5 2084 10 2084 { lab=x25}
N -47.5 2064 10 2064 { lab=k24_bar}
N -47.5 2164 10 2164 { lab=x26}
N -47.5 2144 10 2144 { lab=k25_bar}
N -47.5 2124 10 2124 { lab=k25}
N -47.5 2224 10 2224 { lab=k26_bar}
N -47.5 2204 10 2204 { lab=k26}
N -47.5 2184 10 2184 { lab=x26_bar}
N -47.5 2284 10 2284 { lab=k27}
N -47.5 2264 10 2264 { lab=x27_bar}
N -47.5 2244 10 2244 { lab=x27}
N -47.5 2304 10 2304 { lab=k27_bar}
N -47.5 1984 10 1984 { lab=#net22}
N 310 1984 350 1984 { lab=#net23}
N 310 2004 350 2004 { lab=#net24}
N 310 2024 350 2024 { lab=#net25}
N 310 2044 350 2044 { lab=#net26}
N -47.5 2434 10 2434 { lab=k28}
N -47.5 2414 10 2414 { lab=x28_bar}
N -47.5 2394 10 2394 { lab=x28}
N -47.5 2494 10 2494 { lab=x29_bar}
N -47.5 2474 10 2474 { lab=x29}
N -47.5 2454 10 2454 { lab=k28_bar}
N -47.5 2554 10 2554 { lab=x30}
N -47.5 2534 10 2534 { lab=k29_bar}
N -47.5 2514 10 2514 { lab=k29}
N -47.5 2614 10 2614 { lab=k30_bar}
N -47.5 2594 10 2594 { lab=k30}
N -47.5 2574 10 2574 { lab=x30_bar}
N -47.5 2674 10 2674 { lab=k31}
N -47.5 2654 10 2654 { lab=x31_bar}
N -47.5 2634 10 2634 { lab=x31}
N -47.5 2694 10 2694 { lab=k31_bar}
N -47.5 2374 10 2374 { lab=#net27}
N 310 2374 350 2374 { lab=#net28}
N 310 2394 350 2394 { lab=#net29}
N 310 2414 350 2414 { lab=#net30}
N 310 2434 350 2434 { lab=#net31}
N -47.5 2810 10 2810 { lab=k32}
N -47.5 2790 10 2790 { lab=x32_bar}
N -47.5 2770 10 2770 { lab=x32}
N -47.5 2870 10 2870 { lab=x33_bar}
N -47.5 2850 10 2850 { lab=x33}
N -47.5 2830 10 2830 { lab=k32_bar}
N -47.5 2930 10 2930 { lab=x34}
N -47.5 2910 10 2910 { lab=k33_bar}
N -47.5 2890 10 2890 { lab=k33}
N -47.5 2990 10 2990 { lab=k34_bar}
N -47.5 2970 10 2970 { lab=k34}
N -47.5 2950 10 2950 { lab=x34_bar}
N -47.5 3050 10 3050 { lab=k35}
N -47.5 3030 10 3030 { lab=x35_bar}
N -47.5 3010 10 3010 { lab=x35}
N -47.5 3070 10 3070 { lab=k35_bar}
N -47.5 2750 10 2750 { lab=#net32}
N 310 2750 350 2750 { lab=#net33}
N 310 2770 350 2770 { lab=#net34}
N 310 2790 350 2790 { lab=#net35}
N 310 2810 350 2810 { lab=#net36}
N -47.5 3200 10 3200 { lab=k36}
N -47.5 3180 10 3180 { lab=x36_bar}
N -47.5 3160 10 3160 { lab=x36}
N -47.5 3260 10 3260 { lab=x37_bar}
N -47.5 3240 10 3240 { lab=x37}
N -47.5 3220 10 3220 { lab=k36_bar}
N -47.5 3320 10 3320 { lab=x38}
N -47.5 3300 10 3300 { lab=k37_bar}
N -47.5 3280 10 3280 { lab=k37}
N -47.5 3380 10 3380 { lab=k38_bar}
N -47.5 3360 10 3360 { lab=k38}
N -47.5 3340 10 3340 { lab=x38_bar}
N -47.5 3440 10 3440 { lab=k39}
N -47.5 3420 10 3420 { lab=x39_bar}
N -47.5 3400 10 3400 { lab=x39}
N -47.5 3460 10 3460 { lab=k39_bar}
N -47.5 3140 10 3140 { lab=#net37}
N 310 3140 350 3140 { lab=#net38}
N 310 3160 350 3160 { lab=#net39}
N 310 3180 350 3180 { lab=#net40}
N 310 3200 350 3200 { lab=#net41}
N -47.5 3583 10 3583 { lab=k40}
N -47.5 3563 10 3563 { lab=x40_bar}
N -47.5 3543 10 3543 { lab=x40}
N -47.5 3643 10 3643 { lab=x41_bar}
N -47.5 3623 10 3623 { lab=x41}
N -47.5 3603 10 3603 { lab=k40_bar}
N -47.5 3703 10 3703 { lab=x42}
N -47.5 3683 10 3683 { lab=k41_bar}
N -47.5 3663 10 3663 { lab=k41}
N -47.5 3763 10 3763 { lab=k42_bar}
N -47.5 3743 10 3743 { lab=k42}
N -47.5 3723 10 3723 { lab=x42_bar}
N -47.5 3823 10 3823 { lab=k43}
N -47.5 3803 10 3803 { lab=x43_bar}
N -47.5 3783 10 3783 { lab=x43}
N -47.5 3843 10 3843 { lab=k43_bar}
N -47.5 3523 10 3523 { lab=#net42}
N 310 3523 350 3523 { lab=#net43}
N 310 3543 350 3543 { lab=#net44}
N 310 3563 350 3563 { lab=#net45}
N 310 3583 350 3583 { lab=#net46}
N -47.5 3973 10 3973 { lab=k44}
N -47.5 3953 10 3953 { lab=x44_bar}
N -47.5 3933 10 3933 { lab=x44}
N -47.5 4033 10 4033 { lab=x45_bar}
N -47.5 4013 10 4013 { lab=x45}
N -47.5 3993 10 3993 { lab=k44_bar}
N -47.5 4093 10 4093 { lab=x46}
N -47.5 4073 10 4073 { lab=k45_bar}
N -47.5 4053 10 4053 { lab=k45}
N -47.5 4153 10 4153 { lab=k46_bar}
N -47.5 4133 10 4133 { lab=k46}
N -47.5 4113 10 4113 { lab=x46_bar}
N -47.5 4213 10 4213 { lab=k47}
N -47.5 4193 10 4193 { lab=x47_bar}
N -47.5 4173 10 4173 { lab=x47}
N -47.5 4233 10 4233 { lab=k47_bar}
N -47.5 3913 10 3913 { lab=#net47}
N 310 3913 350 3913 { lab=#net48}
N 310 3933 350 3933 { lab=#net49}
N 310 3953 350 3953 { lab=#net50}
N 310 3973 350 3973 { lab=#net51}
N -47.5 4351 10 4351 { lab=k48}
N -47.5 4331 10 4331 { lab=x48_bar}
N -47.5 4311 10 4311 { lab=x48}
N -47.5 4411 10 4411 { lab=x49_bar}
N -47.5 4391 10 4391 { lab=x49}
N -47.5 4371 10 4371 { lab=k48_bar}
N -47.5 4471 10 4471 { lab=x50}
N -47.5 4451 10 4451 { lab=k49_bar}
N -47.5 4431 10 4431 { lab=k49}
N -47.5 4531 10 4531 { lab=k50_bar}
N -47.5 4511 10 4511 { lab=k50}
N -47.5 4491 10 4491 { lab=x50_bar}
N -47.5 4591 10 4591 { lab=k51}
N -47.5 4571 10 4571 { lab=x51_bar}
N -47.5 4551 10 4551 { lab=x51}
N -47.5 4611 10 4611 { lab=k51_bar}
N -47.5 4291 10 4291 { lab=#net52}
N 310 4291 350 4291 { lab=#net53}
N 310 4311 350 4311 { lab=#net54}
N 310 4331 350 4331 { lab=#net55}
N 310 4351 350 4351 { lab=#net56}
N -47.5 4741 10 4741 { lab=k52}
N -47.5 4721 10 4721 { lab=x52_bar}
N -47.5 4701 10 4701 { lab=x52}
N -47.5 4801 10 4801 { lab=x53_bar}
N -47.5 4781 10 4781 { lab=x53}
N -47.5 4761 10 4761 { lab=k52_bar}
N -47.5 4861 10 4861 { lab=x54}
N -47.5 4841 10 4841 { lab=k53_bar}
N -47.5 4821 10 4821 { lab=k53}
N -47.5 4921 10 4921 { lab=k54_bar}
N -47.5 4901 10 4901 { lab=k54}
N -47.5 4881 10 4881 { lab=x54_bar}
N -47.5 4981 10 4981 { lab=k55}
N -47.5 4961 10 4961 { lab=x55_bar}
N -47.5 4941 10 4941 { lab=x55}
N -47.5 5001 10 5001 { lab=k55_bar}
N -47.5 4681 10 4681 { lab=#net57}
N 310 4681 350 4681 { lab=#net58}
N 310 4701 350 4701 { lab=#net59}
N 310 4721 350 4721 { lab=#net60}
N 310 4741 350 4741 { lab=#net61}
N -47.5 5124 10 5124 { lab=k56}
N -47.5 5104 10 5104 { lab=x56_bar}
N -47.5 5084 10 5084 { lab=x56}
N -47.5 5184 10 5184 { lab=x57_bar}
N -47.5 5164 10 5164 { lab=x57}
N -47.5 5144 10 5144 { lab=k56_bar}
N -47.5 5244 10 5244 { lab=x58}
N -47.5 5224 10 5224 { lab=k57_bar}
N -47.5 5204 10 5204 { lab=k57}
N -47.5 5304 10 5304 { lab=k58_bar}
N -47.5 5284 10 5284 { lab=k58}
N -47.5 5264 10 5264 { lab=x58_bar}
N -47.5 5364 10 5364 { lab=k59}
N -47.5 5344 10 5344 { lab=x59_bar}
N -47.5 5324 10 5324 { lab=x59}
N -47.5 5384 10 5384 { lab=k59_bar}
N -47.5 5064 10 5064 { lab=#net62}
N 310 5064 350 5064 { lab=#net63}
N 310 5084 350 5084 { lab=#net64}
N 310 5104 350 5104 { lab=#net65}
N 310 5124 350 5124 { lab=#net66}
N -47.5 5514 10 5514 { lab=k60}
N -47.5 5494 10 5494 { lab=x60_bar}
N -47.5 5474 10 5474 { lab=x60}
N -47.5 5574 10 5574 { lab=x61_bar}
N -47.5 5554 10 5554 { lab=x61}
N -47.5 5534 10 5534 { lab=k60_bar}
N -47.5 5634 10 5634 { lab=x62}
N -47.5 5614 10 5614 { lab=k61_bar}
N -47.5 5594 10 5594 { lab=k61}
N -47.5 5694 10 5694 { lab=k62_bar}
N -47.5 5674 10 5674 { lab=k62}
N -47.5 5654 10 5654 { lab=x62_bar}
N -47.5 5754 10 5754 { lab=k63}
N -47.5 5734 10 5734 { lab=x63_bar}
N -47.5 5714 10 5714 { lab=x63}
N -47.5 5774 10 5774 { lab=k63_bar}
N -47.5 5454 10 5454 { lab=#net67}
N 310 5454 350 5454 { lab=#net68}
N 310 5474 350 5474 { lab=#net69}
N 310 5494 350 5494 { lab=#net70}
N 310 5514 350 5514 { lab=#net71}
C {CMOS_PRESENT80_R1.sym} 160 -170 0 0 {name=x1}
C {devices/ipin.sym} -47.5 -310 0 0 {name=p0x lab=x0}
C {devices/ipin.sym} -47.5 -290 0 0 {name=p0x_bar lab=x0_bar}
C {devices/ipin.sym} -47.5 -270 0 0 {name=p0k lab=k0}
C {devices/ipin.sym} -47.5 -250 0 0 {name=p0k_bar lab=k0_bar}
C {devices/ipin.sym} -47.5 -230 0 0 {name=p1x lab=x1}
C {devices/ipin.sym} -47.5 -210 0 0 {name=p1x_bar lab=x1_bar}
C {devices/ipin.sym} -47.5 -190 0 0 {name=p1k lab=k1}
C {devices/ipin.sym} -47.5 -170 0 0 {name=p1k_bar lab=k1_bar}
C {devices/ipin.sym} -47.5 -150 0 0 {name=p2x lab=x2}
C {devices/ipin.sym} -47.5 -130 0 0 {name=p2x_bar lab=x2_bar}
C {devices/ipin.sym} -47.5 -110 0 0 {name=p2k lab=k2}
C {devices/ipin.sym} -47.5 -90 0 0 {name=p2k_bar lab=k2_bar}
C {devices/ipin.sym} -47.5 -70 0 0 {name=p3x lab=x3}
C {devices/ipin.sym} -47.5 -50 0 0 {name=p3x_bar lab=x3_bar}
C {devices/ipin.sym} -47.5 -30 0 0 {name=p3k lab=k3}
C {devices/ipin.sym} -47.5 -10 0 0 {name=p3k_bar lab=k3_bar}
C {devices/ipin.sym} -47.5 80 0 0 {name=p4x lab=x4}
C {devices/ipin.sym} -47.5 100 0 0 {name=p4x_bar lab=x4_bar}
C {devices/ipin.sym} -47.5 120 0 0 {name=p4k lab=k4}
C {devices/ipin.sym} -47.5 140 0 0 {name=p4k_bar lab=k4_bar}
C {devices/ipin.sym} -47.5 160 0 0 {name=p5x lab=x5}
C {devices/ipin.sym} -47.5 180 0 0 {name=p5x_bar lab=x5_bar}
C {devices/ipin.sym} -47.5 200 0 0 {name=p5k lab=k5}
C {devices/ipin.sym} -47.5 220 0 0 {name=p5k_bar lab=k5_bar}
C {devices/ipin.sym} -47.5 240 0 0 {name=p6x lab=x6}
C {devices/ipin.sym} -47.5 260 0 0 {name=p6x_bar lab=x6_bar}
C {devices/ipin.sym} -47.5 280 0 0 {name=p6k lab=k6}
C {devices/ipin.sym} -47.5 300 0 0 {name=p6k_bar lab=k6_bar}
C {devices/ipin.sym} -47.5 320 0 0 {name=p7x lab=x7}
C {devices/ipin.sym} -47.5 340 0 0 {name=p7x_bar lab=x7_bar}
C {devices/ipin.sym} -47.5 360 0 0 {name=p7k lab=k7}
C {devices/ipin.sym} -47.5 380 0 0 {name=p7k_bar lab=k7_bar}
C {devices/ipin.sym} -47.5 463 0 0 {name=p8x lab=x8}
C {devices/ipin.sym} -47.5 483 0 0 {name=p8x_bar lab=x8_bar}
C {devices/ipin.sym} -47.5 503 0 0 {name=p8k lab=k8}
C {devices/ipin.sym} -47.5 523 0 0 {name=p8k_bar lab=k8_bar}
C {devices/ipin.sym} -47.5 543 0 0 {name=p9x lab=x9}
C {devices/ipin.sym} -47.5 563 0 0 {name=p9x_bar lab=x9_bar}
C {devices/ipin.sym} -47.5 583 0 0 {name=p9k lab=k9}
C {devices/ipin.sym} -47.5 603 0 0 {name=p9k_bar lab=k9_bar}
C {devices/ipin.sym} -47.5 623 0 0 {name=p10x lab=x10}
C {devices/ipin.sym} -47.5 643 0 0 {name=p10x_bar lab=x10_bar}
C {devices/ipin.sym} -47.5 663 0 0 {name=p10k lab=k10}
C {devices/ipin.sym} -47.5 683 0 0 {name=p10k_bar lab=k10_bar}
C {devices/ipin.sym} -47.5 703 0 0 {name=p11x lab=x11}
C {devices/ipin.sym} -47.5 723 0 0 {name=p11x_bar lab=x11_bar}
C {devices/ipin.sym} -47.5 743 0 0 {name=p11k lab=k11}
C {devices/ipin.sym} -47.5 763 0 0 {name=p11k_bar lab=k11_bar}
C {devices/ipin.sym} -47.5 853 0 0 {name=p12x lab=x12}
C {devices/ipin.sym} -47.5 873 0 0 {name=p12x_bar lab=x12_bar}
C {devices/ipin.sym} -47.5 893 0 0 {name=p12k lab=k12}
C {devices/ipin.sym} -47.5 913 0 0 {name=p12k_bar lab=k12_bar}
C {devices/ipin.sym} -47.5 933 0 0 {name=p13x lab=x13}
C {devices/ipin.sym} -47.5 953 0 0 {name=p13x_bar lab=x13_bar}
C {devices/ipin.sym} -47.5 973 0 0 {name=p13k lab=k13}
C {devices/ipin.sym} -47.5 993 0 0 {name=p13k_bar lab=k13_bar}
C {devices/ipin.sym} -47.5 1013 0 0 {name=p14x lab=x14}
C {devices/ipin.sym} -47.5 1033 0 0 {name=p14x_bar lab=x14_bar}
C {devices/ipin.sym} -47.5 1053 0 0 {name=p14k lab=k14}
C {devices/ipin.sym} -47.5 1073 0 0 {name=p14k_bar lab=k14_bar}
C {devices/ipin.sym} -47.5 1093 0 0 {name=p15x lab=x15}
C {devices/ipin.sym} -47.5 1113 0 0 {name=p15x_bar lab=x15_bar}
C {devices/ipin.sym} -47.5 1133 0 0 {name=p15k lab=k15}
C {devices/ipin.sym} -47.5 1153 0 0 {name=p15k_bar lab=k15_bar}
C {devices/ipin.sym} -47.5 1231 0 0 {name=p16x lab=x16}
C {devices/ipin.sym} -47.5 1251 0 0 {name=p16x_bar lab=x16_bar}
C {devices/ipin.sym} -47.5 1271 0 0 {name=p16k lab=k16}
C {devices/ipin.sym} -47.5 1291 0 0 {name=p16k_bar lab=k16_bar}
C {devices/ipin.sym} -47.5 1311 0 0 {name=p17x lab=x17}
C {devices/ipin.sym} -47.5 1331 0 0 {name=p17x_bar lab=x17_bar}
C {devices/ipin.sym} -47.5 1351 0 0 {name=p17k lab=k17}
C {devices/ipin.sym} -47.5 1371 0 0 {name=p17k_bar lab=k17_bar}
C {devices/ipin.sym} -47.5 1391 0 0 {name=p18x lab=x18}
C {devices/ipin.sym} -47.5 1411 0 0 {name=p18x_bar lab=x18_bar}
C {devices/ipin.sym} -47.5 1431 0 0 {name=p18k lab=k18}
C {devices/ipin.sym} -47.5 1451 0 0 {name=p18k_bar lab=k18_bar}
C {devices/ipin.sym} -47.5 1471 0 0 {name=p19x lab=x19}
C {devices/ipin.sym} -47.5 1491 0 0 {name=p19x_bar lab=x19_bar}
C {devices/ipin.sym} -47.5 1511 0 0 {name=p19k lab=k19}
C {devices/ipin.sym} -47.5 1531 0 0 {name=p19k_bar lab=k19_bar}
C {devices/ipin.sym} -47.5 1621 0 0 {name=p20x lab=x20}
C {devices/ipin.sym} -47.5 1641 0 0 {name=p20x_bar lab=x20_bar}
C {devices/ipin.sym} -47.5 1661 0 0 {name=p20k lab=k20}
C {devices/ipin.sym} -47.5 1681 0 0 {name=p20k_bar lab=k20_bar}
C {devices/ipin.sym} -47.5 1701 0 0 {name=p21x lab=x21}
C {devices/ipin.sym} -47.5 1721 0 0 {name=p21x_bar lab=x21_bar}
C {devices/ipin.sym} -47.5 1741 0 0 {name=p21k lab=k21}
C {devices/ipin.sym} -47.5 1761 0 0 {name=p21k_bar lab=k21_bar}
C {devices/ipin.sym} -47.5 1781 0 0 {name=p22x lab=x22}
C {devices/ipin.sym} -47.5 1801 0 0 {name=p22x_bar lab=x22_bar}
C {devices/ipin.sym} -47.5 1821 0 0 {name=p22k lab=k22}
C {devices/ipin.sym} -47.5 1841 0 0 {name=p22k_bar lab=k22_bar}
C {devices/ipin.sym} -47.5 1861 0 0 {name=p23x lab=x23}
C {devices/ipin.sym} -47.5 1881 0 0 {name=p23x_bar lab=x23_bar}
C {devices/ipin.sym} -47.5 1901 0 0 {name=p23k lab=k23}
C {devices/ipin.sym} -47.5 1921 0 0 {name=p23k_bar lab=k23_bar}
C {devices/ipin.sym} -47.5 2004 0 0 {name=p24x lab=x24}
C {devices/ipin.sym} -47.5 2024 0 0 {name=p24x_bar lab=x24_bar}
C {devices/ipin.sym} -47.5 2044 0 0 {name=p24k lab=k24}
C {devices/ipin.sym} -47.5 2064 0 0 {name=p24k_bar lab=k24_bar}
C {devices/ipin.sym} -47.5 2084 0 0 {name=p25x lab=x25}
C {devices/ipin.sym} -47.5 2104 0 0 {name=p25x_bar lab=x25_bar}
C {devices/ipin.sym} -47.5 2124 0 0 {name=p25k lab=k25}
C {devices/ipin.sym} -47.5 2144 0 0 {name=p25k_bar lab=k25_bar}
C {devices/ipin.sym} -47.5 2164 0 0 {name=p26x lab=x26}
C {devices/ipin.sym} -47.5 2184 0 0 {name=p26x_bar lab=x26_bar}
C {devices/ipin.sym} -47.5 2204 0 0 {name=p26k lab=k26}
C {devices/ipin.sym} -47.5 2224 0 0 {name=p26k_bar lab=k26_bar}
C {devices/ipin.sym} -47.5 2244 0 0 {name=p27x lab=x27}
C {devices/ipin.sym} -47.5 2264 0 0 {name=p27x_bar lab=x27_bar}
C {devices/ipin.sym} -47.5 2284 0 0 {name=p27k lab=k27}
C {devices/ipin.sym} -47.5 2304 0 0 {name=p27k_bar lab=k27_bar}
C {devices/ipin.sym} -47.5 2394 0 0 {name=p28x lab=x28}
C {devices/ipin.sym} -47.5 2414 0 0 {name=p28x_bar lab=x28_bar}
C {devices/ipin.sym} -47.5 2434 0 0 {name=p28k lab=k28}
C {devices/ipin.sym} -47.5 2454 0 0 {name=p28k_bar lab=k28_bar}
C {devices/ipin.sym} -47.5 2474 0 0 {name=p29x lab=x29}
C {devices/ipin.sym} -47.5 2494 0 0 {name=p29x_bar lab=x29_bar}
C {devices/ipin.sym} -47.5 2514 0 0 {name=p29k lab=k29}
C {devices/ipin.sym} -47.5 2534 0 0 {name=p29k_bar lab=k29_bar}
C {devices/ipin.sym} -47.5 2554 0 0 {name=p30x lab=x30}
C {devices/ipin.sym} -47.5 2574 0 0 {name=p30x_bar lab=x30_bar}
C {devices/ipin.sym} -47.5 2594 0 0 {name=p30k lab=k30}
C {devices/ipin.sym} -47.5 2614 0 0 {name=p30k_bar lab=k30_bar}
C {devices/ipin.sym} -47.5 2634 0 0 {name=p31x lab=x31}
C {devices/ipin.sym} -47.5 2654 0 0 {name=p31x_bar lab=x31_bar}
C {devices/ipin.sym} -47.5 2674 0 0 {name=p31k lab=k31}
C {devices/ipin.sym} -47.5 2694 0 0 {name=p31k_bar lab=k31_bar}
C {devices/ipin.sym} -47.5 2770 0 0 {name=p32x lab=x32}
C {devices/ipin.sym} -47.5 2790 0 0 {name=p32x_bar lab=x32_bar}
C {devices/ipin.sym} -47.5 2810 0 0 {name=p32k lab=k32}
C {devices/ipin.sym} -47.5 2830 0 0 {name=p32k_bar lab=k32_bar}
C {devices/ipin.sym} -47.5 2850 0 0 {name=p33x lab=x33}
C {devices/ipin.sym} -47.5 2870 0 0 {name=p33x_bar lab=x33_bar}
C {devices/ipin.sym} -47.5 2890 0 0 {name=p33k lab=k33}
C {devices/ipin.sym} -47.5 2910 0 0 {name=p33k_bar lab=k33_bar}
C {devices/ipin.sym} -47.5 2930 0 0 {name=p34x lab=x34}
C {devices/ipin.sym} -47.5 2950 0 0 {name=p34x_bar lab=x34_bar}
C {devices/ipin.sym} -47.5 2970 0 0 {name=p34k lab=k34}
C {devices/ipin.sym} -47.5 2990 0 0 {name=p34k_bar lab=k34_bar}
C {devices/ipin.sym} -47.5 3010 0 0 {name=p35x lab=x35}
C {devices/ipin.sym} -47.5 3030 0 0 {name=p35x_bar lab=x35_bar}
C {devices/ipin.sym} -47.5 3050 0 0 {name=p35k lab=k35}
C {devices/ipin.sym} -47.5 3070 0 0 {name=p35k_bar lab=k35_bar}
C {devices/ipin.sym} -47.5 3160 0 0 {name=p36x lab=x36}
C {devices/ipin.sym} -47.5 3180 0 0 {name=p36x_bar lab=x36_bar}
C {devices/ipin.sym} -47.5 3200 0 0 {name=p36k lab=k36}
C {devices/ipin.sym} -47.5 3220 0 0 {name=p36k_bar lab=k36_bar}
C {devices/ipin.sym} -47.5 3240 0 0 {name=p37x lab=x37}
C {devices/ipin.sym} -47.5 3260 0 0 {name=p37x_bar lab=x37_bar}
C {devices/ipin.sym} -47.5 3280 0 0 {name=p37k lab=k37}
C {devices/ipin.sym} -47.5 3300 0 0 {name=p37k_bar lab=k37_bar}
C {devices/ipin.sym} -47.5 3320 0 0 {name=p38x lab=x38}
C {devices/ipin.sym} -47.5 3340 0 0 {name=p38x_bar lab=x38_bar}
C {devices/ipin.sym} -47.5 3360 0 0 {name=p38k lab=k38}
C {devices/ipin.sym} -47.5 3380 0 0 {name=p38k_bar lab=k38_bar}
C {devices/ipin.sym} -47.5 3400 0 0 {name=p39x lab=x39}
C {devices/ipin.sym} -47.5 3420 0 0 {name=p39x_bar lab=x39_bar}
C {devices/ipin.sym} -47.5 3440 0 0 {name=p39k lab=k39}
C {devices/ipin.sym} -47.5 3460 0 0 {name=p39k_bar lab=k39_bar}
C {devices/ipin.sym} -47.5 3543 0 0 {name=p40x lab=x40}
C {devices/ipin.sym} -47.5 3563 0 0 {name=p40x_bar lab=x40_bar}
C {devices/ipin.sym} -47.5 3583 0 0 {name=p40k lab=k40}
C {devices/ipin.sym} -47.5 3603 0 0 {name=p40k_bar lab=k40_bar}
C {devices/ipin.sym} -47.5 3623 0 0 {name=p41x lab=x41}
C {devices/ipin.sym} -47.5 3643 0 0 {name=p41x_bar lab=x41_bar}
C {devices/ipin.sym} -47.5 3663 0 0 {name=p41k lab=k41}
C {devices/ipin.sym} -47.5 3683 0 0 {name=p41k_bar lab=k41_bar}
C {devices/ipin.sym} -47.5 3703 0 0 {name=p42x lab=x42}
C {devices/ipin.sym} -47.5 3723 0 0 {name=p42x_bar lab=x42_bar}
C {devices/ipin.sym} -47.5 3743 0 0 {name=p42k lab=k42}
C {devices/ipin.sym} -47.5 3763 0 0 {name=p42k_bar lab=k42_bar}
C {devices/ipin.sym} -47.5 3783 0 0 {name=p43x lab=x43}
C {devices/ipin.sym} -47.5 3803 0 0 {name=p43x_bar lab=x43_bar}
C {devices/ipin.sym} -47.5 3823 0 0 {name=p43k lab=k43}
C {devices/ipin.sym} -47.5 3843 0 0 {name=p43k_bar lab=k43_bar}
C {devices/ipin.sym} -47.5 3933 0 0 {name=p44x lab=x44}
C {devices/ipin.sym} -47.5 3953 0 0 {name=p44x_bar lab=x44_bar}
C {devices/ipin.sym} -47.5 3973 0 0 {name=p44k lab=k44}
C {devices/ipin.sym} -47.5 3993 0 0 {name=p44k_bar lab=k44_bar}
C {devices/ipin.sym} -47.5 4013 0 0 {name=p45x lab=x45}
C {devices/ipin.sym} -47.5 4033 0 0 {name=p45x_bar lab=x45_bar}
C {devices/ipin.sym} -47.5 4053 0 0 {name=p45k lab=k45}
C {devices/ipin.sym} -47.5 4073 0 0 {name=p45k_bar lab=k45_bar}
C {devices/ipin.sym} -47.5 4093 0 0 {name=p46x lab=x46}
C {devices/ipin.sym} -47.5 4113 0 0 {name=p46x_bar lab=x46_bar}
C {devices/ipin.sym} -47.5 4133 0 0 {name=p46k lab=k46}
C {devices/ipin.sym} -47.5 4153 0 0 {name=p46k_bar lab=k46_bar}
C {devices/ipin.sym} -47.5 4173 0 0 {name=p47x lab=x47}
C {devices/ipin.sym} -47.5 4193 0 0 {name=p47x_bar lab=x47_bar}
C {devices/ipin.sym} -47.5 4213 0 0 {name=p47k lab=k47}
C {devices/ipin.sym} -47.5 4233 0 0 {name=p47k_bar lab=k47_bar}
C {devices/ipin.sym} -47.5 4311 0 0 {name=p48x lab=x48}
C {devices/ipin.sym} -47.5 4331 0 0 {name=p48x_bar lab=x48_bar}
C {devices/ipin.sym} -47.5 4351 0 0 {name=p48k lab=k48}
C {devices/ipin.sym} -47.5 4371 0 0 {name=p48k_bar lab=k48_bar}
C {devices/ipin.sym} -47.5 4391 0 0 {name=p49x lab=x49}
C {devices/ipin.sym} -47.5 4411 0 0 {name=p49x_bar lab=x49_bar}
C {devices/ipin.sym} -47.5 4431 0 0 {name=p49k lab=k49}
C {devices/ipin.sym} -47.5 4451 0 0 {name=p49k_bar lab=k49_bar}
C {devices/ipin.sym} -47.5 4471 0 0 {name=p50x lab=x50}
C {devices/ipin.sym} -47.5 4491 0 0 {name=p50x_bar lab=x50_bar}
C {devices/ipin.sym} -47.5 4511 0 0 {name=p50k lab=k50}
C {devices/ipin.sym} -47.5 4531 0 0 {name=p50k_bar lab=k50_bar}
C {devices/ipin.sym} -47.5 4551 0 0 {name=p51x lab=x51}
C {devices/ipin.sym} -47.5 4571 0 0 {name=p51x_bar lab=x51_bar}
C {devices/ipin.sym} -47.5 4591 0 0 {name=p51k lab=k51}
C {devices/ipin.sym} -47.5 4611 0 0 {name=p51k_bar lab=k51_bar}
C {devices/ipin.sym} -47.5 4701 0 0 {name=p52x lab=x52}
C {devices/ipin.sym} -47.5 4721 0 0 {name=p52x_bar lab=x52_bar}
C {devices/ipin.sym} -47.5 4741 0 0 {name=p52k lab=k52}
C {devices/ipin.sym} -47.5 4761 0 0 {name=p52k_bar lab=k52_bar}
C {devices/ipin.sym} -47.5 4781 0 0 {name=p53x lab=x53}
C {devices/ipin.sym} -47.5 4801 0 0 {name=p53x_bar lab=x53_bar}
C {devices/ipin.sym} -47.5 4821 0 0 {name=p53k lab=k53}
C {devices/ipin.sym} -47.5 4841 0 0 {name=p53k_bar lab=k53_bar}
C {devices/ipin.sym} -47.5 4861 0 0 {name=p54x lab=x54}
C {devices/ipin.sym} -47.5 4881 0 0 {name=p54x_bar lab=x54_bar}
C {devices/ipin.sym} -47.5 4901 0 0 {name=p54k lab=k54}
C {devices/ipin.sym} -47.5 4921 0 0 {name=p54k_bar lab=k54_bar}
C {devices/ipin.sym} -47.5 4941 0 0 {name=p55x lab=x55}
C {devices/ipin.sym} -47.5 4961 0 0 {name=p55x_bar lab=x55_bar}
C {devices/ipin.sym} -47.5 4981 0 0 {name=p55k lab=k55}
C {devices/ipin.sym} -47.5 5001 0 0 {name=p55k_bar lab=k55_bar}
C {devices/ipin.sym} -47.5 5084 0 0 {name=p56x lab=x56}
C {devices/ipin.sym} -47.5 5104 0 0 {name=p56x_bar lab=x56_bar}
C {devices/ipin.sym} -47.5 5124 0 0 {name=p56k lab=k56}
C {devices/ipin.sym} -47.5 5144 0 0 {name=p56k_bar lab=k56_bar}
C {devices/ipin.sym} -47.5 5164 0 0 {name=p57x lab=x57}
C {devices/ipin.sym} -47.5 5184 0 0 {name=p57x_bar lab=x57_bar}
C {devices/ipin.sym} -47.5 5204 0 0 {name=p57k lab=k57}
C {devices/ipin.sym} -47.5 5224 0 0 {name=p57k_bar lab=k57_bar}
C {devices/ipin.sym} -47.5 5244 0 0 {name=p58x lab=x58}
C {devices/ipin.sym} -47.5 5264 0 0 {name=p58x_bar lab=x58_bar}
C {devices/ipin.sym} -47.5 5284 0 0 {name=p58k lab=k58}
C {devices/ipin.sym} -47.5 5304 0 0 {name=p58k_bar lab=k58_bar}
C {devices/ipin.sym} -47.5 5324 0 0 {name=p59x lab=x59}
C {devices/ipin.sym} -47.5 5344 0 0 {name=p59x_bar lab=x59_bar}
C {devices/ipin.sym} -47.5 5364 0 0 {name=p59k lab=k59}
C {devices/ipin.sym} -47.5 5384 0 0 {name=p59k_bar lab=k59_bar}
C {devices/ipin.sym} -47.5 5474 0 0 {name=p60x lab=x60}
C {devices/ipin.sym} -47.5 5494 0 0 {name=p60x_bar lab=x60_bar}
C {devices/ipin.sym} -47.5 5514 0 0 {name=p60k lab=k60}
C {devices/ipin.sym} -47.5 5534 0 0 {name=p60k_bar lab=k60_bar}
C {devices/ipin.sym} -47.5 5554 0 0 {name=p61x lab=x61}
C {devices/ipin.sym} -47.5 5574 0 0 {name=p61x_bar lab=x61_bar}
C {devices/ipin.sym} -47.5 5594 0 0 {name=p61k lab=k61}
C {devices/ipin.sym} -47.5 5614 0 0 {name=p61k_bar lab=k61_bar}
C {devices/ipin.sym} -47.5 5634 0 0 {name=p62x lab=x62}
C {devices/ipin.sym} -47.5 5654 0 0 {name=p62x_bar lab=x62_bar}
C {devices/ipin.sym} -47.5 5674 0 0 {name=p62k lab=k62}
C {devices/ipin.sym} -47.5 5694 0 0 {name=p62k_bar lab=k62_bar}
C {devices/ipin.sym} -47.5 5714 0 0 {name=p63x lab=x63}
C {devices/ipin.sym} -47.5 5734 0 0 {name=p63x_bar lab=x63_bar}
C {devices/ipin.sym} -47.5 5754 0 0 {name=p63k lab=k63}
C {devices/ipin.sym} -47.5 5774 0 0 {name=p63k_bar lab=k63_bar}
C {devices/opin.sym} 350 -330 0 0 {name=p0s lab=s0}
C {devices/opin.sym} 350 -310 0 0 {name=p1s lab=s1}
C {devices/opin.sym} 350 -290 0 0 {name=p2s lab=s2}
C {devices/opin.sym} 350 -270 0 0 {name=p3s lab=s3}
C {devices/opin.sym} 350 60 0 0 {name=p4s lab=s4}
C {devices/opin.sym} 350 80 0 0 {name=p5s lab=s5}
C {devices/opin.sym} 350 100 0 0 {name=p6s lab=s6}
C {devices/opin.sym} 350 120 0 0 {name=p7s lab=s7}
C {devices/opin.sym} 349.5 442.5 0 0 {name=p8s lab=s8}
C {devices/opin.sym} 349.5 462.5 0 0 {name=p9s lab=s9}
C {devices/opin.sym} 349.5 482.5 0 0 {name=p10s lab=s10}
C {devices/opin.sym} 349.5 502.5 0 0 {name=p11s lab=s11}
C {devices/opin.sym} 349.5 832.5 0 0 {name=p12s lab=s12}
C {devices/opin.sym} 349.5 852.5 0 0 {name=p13s lab=s13}
C {devices/opin.sym} 349.5 872.5 0 0 {name=p14s lab=s14}
C {devices/opin.sym} 349.5 892.5 0 0 {name=p15s lab=s15}
C {devices/opin.sym} 349.5 1211.5 0 0 {name=p16s lab=s16}
C {devices/opin.sym} 349.5 1231.5 0 0 {name=p17s lab=s17}
C {devices/opin.sym} 349.5 1251.5 0 0 {name=p18s lab=s18}
C {devices/opin.sym} 349.5 1271.5 0 0 {name=p19s lab=s19}
C {devices/opin.sym} 349.5 1601.5 0 0 {name=p20s lab=s20}
C {devices/opin.sym} 349.5 1621.5 0 0 {name=p21s lab=s21}
C {devices/opin.sym} 349.5 1641.5 0 0 {name=p22s lab=s22}
C {devices/opin.sym} 349.5 1661.5 0 0 {name=p23s lab=s23}
C {devices/opin.sym} 349.5 1984.5 0 0 {name=p24s lab=s24}
C {devices/opin.sym} 349.5 2004.5 0 0 {name=p25s lab=s25}
C {devices/opin.sym} 349.5 2024.5 0 0 {name=p26s lab=s26}
C {devices/opin.sym} 349.5 2044.5 0 0 {name=p27s lab=s27}
C {devices/opin.sym} 349.5 2374.5 0 0 {name=p28s lab=s28}
C {devices/opin.sym} 349.5 2394.5 0 0 {name=p29s lab=s29}
C {devices/opin.sym} 349.5 2414.5 0 0 {name=p30s lab=s30}
C {devices/opin.sym} 349.5 2434.5 0 0 {name=p31s lab=s31}
C {devices/opin.sym} 349.5 2750.5 0 0 {name=p32s lab=s32}
C {devices/opin.sym} 349.5 2770.5 0 0 {name=p33s lab=s33}
C {devices/opin.sym} 349.5 2790.5 0 0 {name=p34s lab=s34}
C {devices/opin.sym} 349.5 2810.5 0 0 {name=p35s lab=s35}
C {devices/opin.sym} 349.5 3140.5 0 0 {name=p36s lab=s36}
C {devices/opin.sym} 349.5 3160.5 0 0 {name=p37s lab=s37}
C {devices/opin.sym} 349.5 3180.5 0 0 {name=p38s lab=s38}
C {devices/opin.sym} 349.5 3200.5 0 0 {name=p39s lab=s39}
C {devices/opin.sym} 349.5 3523.5 0 0 {name=p40s lab=s40}
C {devices/opin.sym} 349.5 3543.5 0 0 {name=p41s lab=s41}
C {devices/opin.sym} 349.5 3563.5 0 0 {name=p42s lab=s42}
C {devices/opin.sym} 349.5 3583.5 0 0 {name=p43s lab=s43}
C {devices/opin.sym} 350.5 3912.5 0 0 {name=p44s lab=s44}
C {devices/opin.sym} 350.5 3932.5 0 0 {name=p45s lab=s45}
C {devices/opin.sym} 350.5 3952.5 0 0 {name=p46s lab=s46}
C {devices/opin.sym} 350.5 3972.5 0 0 {name=p47s lab=s47}
C {devices/opin.sym} 349.5 4290.5 0 0 {name=p48s lab=s48}
C {devices/opin.sym} 349.5 4310.5 0 0 {name=p49s lab=s49}
C {devices/opin.sym} 349.5 4330.5 0 0 {name=p50s lab=s50}
C {devices/opin.sym} 349.5 4350.5 0 0 {name=p51s lab=s51}
C {devices/opin.sym} 349.5 4681.5 0 0 {name=p52s lab=s52}
C {devices/opin.sym} 349.5 4701.5 0 0 {name=p53s lab=s53}
C {devices/opin.sym} 349.5 4721.5 0 0 {name=p54s lab=s54}
C {devices/opin.sym} 349.5 4741.5 0 0 {name=p55s lab=s55}
C {devices/opin.sym} 349.5 5063.5 0 0 {name=p56s lab=s56}
C {devices/opin.sym} 349.5 5083.5 0 0 {name=p57s lab=s57}
C {devices/opin.sym} 349.5 5103.5 0 0 {name=p58s lab=s58}
C {devices/opin.sym} 349.5 5123.5 0 0 {name=p59s lab=s59}
C {devices/opin.sym} 349.5 5453.5 0 0 {name=p60s lab=s60}
C {devices/opin.sym} 349.5 5473.5 0 0 {name=p61s lab=s61}
C {devices/opin.sym} 349.5 5493.5 0 0 {name=p62s lab=s62}
C {devices/opin.sym} 349.5 5513.5 0 0 {name=p63s lab=s63}
C {devices/ipin.sym} -47.5 -330 0 0 {name=p1 lab=VDD}
C {devices/gnd.sym} 310 -250 0 0 {name=l1 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 220 0 0 {name=x2}
C {devices/gnd.sym} 310 140 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -48.5 60 0 0 {name=l17 lab=VDD}
C {CMOS_PRESENT80_R1.sym} 160 603 0 0 {name=x3}
C {devices/gnd.sym} 310 523 0 0 {name=l3 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 993 0 0 {name=x4}
C {devices/gnd.sym} 310 913 0 0 {name=l4 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 1371 0 0 {name=x5}
C {devices/gnd.sym} 310 1291 0 0 {name=l5 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 1761 0 0 {name=x6}
C {devices/gnd.sym} 310 1681 0 0 {name=l6 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 2144 0 0 {name=x7}
C {devices/gnd.sym} 310 2064 0 0 {name=l7 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 2534 0 0 {name=x8}
C {devices/gnd.sym} 310 2454 0 0 {name=l8 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 2910 0 0 {name=x9}
C {devices/gnd.sym} 310 2830 0 0 {name=l9 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 3300 0 0 {name=x10}
C {devices/gnd.sym} 310 3220 0 0 {name=l10 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 3683 0 0 {name=x11}
C {devices/gnd.sym} 310 3603 0 0 {name=l11 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 4073 0 0 {name=x12}
C {devices/gnd.sym} 310 3993 0 0 {name=l12 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 4451 0 0 {name=x13}
C {devices/gnd.sym} 310 4371 0 0 {name=l13 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 4841 0 0 {name=x14}
C {devices/gnd.sym} 310 4761 0 0 {name=l14 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 5224 0 0 {name=x15}
C {devices/gnd.sym} 310 5144 0 0 {name=l15 lab=GND}
C {CMOS_PRESENT80_R1.sym} 160 5614 0 0 {name=x16}
C {devices/gnd.sym} 310 5534 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} -48.5 443 0 0 {name=l18 lab=VDD}
C {devices/lab_pin.sym} -48.5 833 0 0 {name=l19 lab=VDD}
C {devices/lab_pin.sym} -48.5 1211 0 0 {name=l20 lab=VDD}
C {devices/lab_pin.sym} -48.5 1601 0 0 {name=l21 lab=VDD}
C {devices/lab_pin.sym} -48.5 1984 0 0 {name=l22 lab=VDD}
C {devices/lab_pin.sym} -48.5 2374 0 0 {name=l23 lab=VDD}
C {devices/lab_pin.sym} -48.5 2750 0 0 {name=l24 lab=VDD}
C {devices/lab_pin.sym} -48.5 3140 0 0 {name=l25 lab=VDD}
C {devices/lab_pin.sym} -48.5 3523 0 0 {name=l26 lab=VDD}
C {devices/lab_pin.sym} -48.5 3913 0 0 {name=l27 lab=VDD}
C {devices/lab_pin.sym} -48.5 4291 0 0 {name=l28 lab=VDD}
C {devices/lab_pin.sym} -48.5 4681 0 0 {name=l29 lab=VDD}
C {devices/lab_pin.sym} -48.5 5064 0 0 {name=l30 lab=VDD}
C {devices/lab_pin.sym} -48.5 5454 0 0 {name=l31 lab=VDD}
