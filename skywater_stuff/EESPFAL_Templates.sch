v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 310 -340 330 -340 { lab=x0_buff}
N 310 -320 330 -320 { lab=x0_bar_buff}
N 310 -300 330 -300 { lab=x3_buff}
N 310 -280 330 -280 { lab=x3_bar_buff}
N 310 -260 330 -260 { lab=Dis1}
N 310 -240 330 -240 { lab=CLK1}
N 310 -190 330 -190 { lab=x1_buff}
N 310 -170 330 -170 { lab=x1_bar_buff}
N 310 -150 330 -150 { lab=x2_bar_buff}
N 310 -130 330 -130 { lab=x2_buff}
N 310 -110 330 -110 { lab=Dis1}
N 310 -90 330 -90 { lab=CLK1}
N 310 -30 330 -30 { lab=x2_buff}
N 310 -10 330 -10 { lab=x2_bar_buff}
N 310 10 330 10 { lab=x1_bar_buff}
N 310 30 330 30 { lab=x1_buff}
N 310 50 330 50 { lab=Dis1}
N 310 70 330 70 { lab=CLK1}
N 630 -340 650 -340 { lab=XOR1}
N 630 -320 650 -320 { lab=XNOR1}
N 630 -190 650 -190 { lab=OR1}
N 630 -170 650 -170 { lab=NOR1}
N 630 -30 650 -30 { lab=AND1}
N 630 -10 650 -10 { lab=NAND1}
N 650 -340 790 -340 { lab=XOR1}
N 790 -340 790 -290 { lab=XOR1}
N 790 -290 830 -290 { lab=XOR1}
N 650 -320 760 -320 { lab=XNOR1}
N 760 -320 760 -270 { lab=XNOR1}
N 760 -270 830 -270 { lab=XNOR1}
N 800 -190 830 -190 { lab=CLK2}
N 800 -210 830 -210 { lab=Dis2}
N 650 -250 650 -190 { lab=OR1}
N 650 -250 830 -250 { lab=OR1}
N 650 -170 670 -170 { lab=NOR1}
N 670 -230 670 -170 { lab=NOR1}
N 670 -230 830 -230 { lab=NOR1}
N 780 -270 780 -70 { lab=XNOR1}
N 780 -70 830 -70 { lab=XNOR1}
N 770 -340 770 -50 { lab=XOR1}
N 770 -50 830 -50 { lab=XOR1}
N 650 -30 830 -30 { lab=AND1}
N 650 -10 830 -10 { lab=NAND1}
N 800 10 830 10 { lab=Dis2}
N 800 30 830 30 { lab=CLK2}
N 1130 -290 1160 -290 { lab=AND2}
N 1130 -270 1160 -270 { lab=NAND2}
N 1130 -70 1160 -70 { lab=AND3}
N 1130 -50 1160 -50 { lab=NAND3}
N 1290 -100 1320 -100 { lab=CLK3}
N 1290 -120 1320 -120 { lab=Dis3}
N 1160 -290 1270 -290 { lab=AND2}
N 1270 -290 1270 -200 { lab=AND2}
N 1270 -200 1320 -200 { lab=AND2}
N 1160 -270 1250 -270 { lab=NAND2}
N 1250 -270 1250 -190 { lab=NAND2}
N 1250 -190 1250 -180 { lab=NAND2}
N 1250 -180 1320 -180 { lab=NAND2}
N 1160 -70 1210 -70 { lab=AND3}
N 1210 -160 1210 -70 { lab=AND3}
N 1210 -160 1320 -160 { lab=AND3}
N 1160 -50 1230 -50 { lab=NAND3}
N 1230 -140 1230 -50 { lab=NAND3}
N 1230 -140 1320 -140 { lab=NAND3}
N 1620 -200 1650 -200 { lab=s0}
N 1620 -180 1650 -180 { lab=s0_bar}
N 1620 -160 1640 -160 { lab=GND}
N 1130 -30 1160 -30 { lab=GND}
N 1130 -250 1160 -250 { lab=GND}
N 630 10 660 10 { lab=GND}
N 630 -150 660 -150 { lab=GND}
N 630 -300 660 -300 { lab=GND}
N 1660 -160 1660 -140 { lab=GND}
N 1650 -160 1660 -160 { lab=GND}
N 1640 -160 1650 -160 { lab=GND}
N -320 -340 -300 -340 { lab=x0}
N -320 -320 -300 -320 { lab=x0_bar}
N -320 -300 -300 -300 { lab=x1}
N -320 -280 -300 -280 { lab=x1_bar}
N -320 -260 -300 -260 { lab=x2}
N -320 -240 -300 -240 { lab=x2_bar}
N -320 -220 -300 -220 { lab=x3}
N -320 -200 -300 -200 { lab=x3_bar}
N -320 -180 -300 -180 { lab=CLK0}
N -320 -160 -300 -160 { lab=Dis0}
N 0 -340 30 -340 { lab=x0_bar_buff}
N 0 -320 30 -320 { lab=x0_buff}
N 0 -300 30 -300 { lab=x1_bar_buff}
N 0 -280 30 -280 { lab=x1_buff}
N 0 -260 30 -260 { lab=x2_bar_buff}
N 0 -240 30 -240 { lab=x2_buff}
N 0 -220 30 -220 { lab=x3_bar_buff}
N 0 -200 30 -200 { lab=x3_buff}
N 330 180 350 180 { lab=x0}
N 330 200 350 200 { lab=x0_bar}
N 330 220 350 220 { lab=x3}
N 330 240 350 240 { lab=x3_bar}
N 330 260 350 260 { lab=Dis0}
N 330 280 350 280 { lab=CLK0}
N 330 330 350 330 { lab=x1}
N 330 350 350 350 { lab=x1_bar}
N 330 370 350 370 { lab=x2_bar}
N 330 390 350 390 { lab=x2}
N 330 410 350 410 { lab=Dis0}
N 330 430 350 430 { lab=CLK0}
N 330 490 350 490 { lab=x2}
N 330 510 350 510 { lab=x2_bar}
N 330 530 350 530 { lab=x1_bar}
N 330 550 350 550 { lab=x1}
N 330 570 350 570 { lab=Dis0}
N 330 590 350 590 { lab=CLK0}
N 650 180 670 180 { lab=XOR1}
N 650 200 670 200 { lab=XNOR1}
N 650 330 670 330 { lab=OR1}
N 650 350 670 350 { lab=NOR1}
N 650 490 670 490 { lab=AND1}
N 650 510 670 510 { lab=NAND1}
N 670 180 810 180 { lab=XOR1}
N 810 180 810 230 { lab=XOR1}
N 810 230 850 230 { lab=XOR1}
N 670 200 780 200 { lab=XNOR1}
N 780 200 780 250 { lab=XNOR1}
N 780 250 850 250 { lab=XNOR1}
N 820 330 850 330 { lab=CLK1}
N 820 310 850 310 { lab=Dis1}
N 670 270 670 330 { lab=OR1}
N 670 270 850 270 { lab=OR1}
N 670 350 690 350 { lab=NOR1}
N 690 290 690 350 { lab=NOR1}
N 690 290 850 290 { lab=NOR1}
N 800 250 800 450 { lab=XNOR1}
N 800 450 850 450 { lab=XNOR1}
N 790 180 790 470 { lab=XOR1}
N 790 470 850 470 { lab=XOR1}
N 670 490 850 490 { lab=AND1}
N 670 510 850 510 { lab=NAND1}
N 820 530 850 530 { lab=Dis1}
N 820 550 850 550 { lab=CLK1}
N 1150 230 1180 230 { lab=AND2}
N 1150 250 1180 250 { lab=NAND2}
N 1150 450 1180 450 { lab=AND3}
N 1150 470 1180 470 { lab=NAND3}
N 1310 420 1340 420 { lab=CLK2}
N 1310 400 1340 400 { lab=Dis2}
N 1180 230 1290 230 { lab=AND2}
N 1290 230 1290 320 { lab=AND2}
N 1290 320 1340 320 { lab=AND2}
N 1180 250 1270 250 { lab=NAND2}
N 1270 250 1270 330 { lab=NAND2}
N 1270 330 1270 340 { lab=NAND2}
N 1270 340 1340 340 { lab=NAND2}
N 1180 450 1230 450 { lab=AND3}
N 1230 360 1230 450 { lab=AND3}
N 1230 360 1340 360 { lab=AND3}
N 1180 470 1250 470 { lab=NAND3}
N 1250 380 1250 470 { lab=NAND3}
N 1250 380 1340 380 { lab=NAND3}
N 1640 320 1670 320 { lab=s0}
N 1640 340 1670 340 { lab=s0_bar}
N 1640 360 1660 360 { lab=GND}
N 1150 490 1180 490 { lab=GND}
N 1150 270 1180 270 { lab=GND}
N 650 530 680 530 { lab=GND}
N 650 370 680 370 { lab=GND}
N 650 220 680 220 { lab=GND}
N 210 260 320 260 { lab=Dis0_S}
N 210 280 320 280 { lab=CLK0_S}
N 210 350 320 350 { lab=x1_bar_S}
N 210 370 320 370 { lab=x2_bar_S}
N 210 390 320 390 { lab=x2_S}
N 750 310 810 310 { lab=Dis1_S}
N 750 330 810 330 { lab=CLK1_S}
N 1220 400 1300 400 { lab=Dis2_S}
N 1220 420 1300 420 { lab=CLK2_S}
N 1680 360 1680 380 { lab=GND}
N 1670 360 1680 360 { lab=GND}
N 210 180 320 180 { lab=x0_S}
N 210 200 320 200 { lab=x0_bar_S}
N 210 220 320 220 { lab=x3_S}
N 210 240 320 240 { lab=x3_bar_S}
N -700 260 -700 280 { lab=x0_bar_S}
N -700 340 -700 360 { lab=GND}
N -670 290 -670 310 { lab=x0_S}
N -670 370 -670 390 { lab=GND}
N -640 320 -640 340 { lab=x1_bar_S}
N -640 400 -640 420 { lab=GND}
N -610 350 -610 370 { lab=x1_S}
N -610 420 -610 440 { lab=GND}
N -580 380 -580 400 { lab=x2_bar_S}
N -580 460 -580 480 { lab=GND}
N -550 410 -550 430 { lab=x2_S}
N -550 490 -550 510 { lab=GND}
N -520 440 -520 460 { lab=x3_bar_S}
N -520 520 -520 540 { lab=GND}
N -490 470 -490 490 { lab=x3_S}
N -490 550 -490 570 { lab=GND}
N -710 -160 -710 -120 { lab=CLK0_S}
N -710 -60 -710 -40 { lab=GND}
N -710 30 -710 70 { lab=Dis0_S}
N -710 130 -710 150 { lab=GND}
N -670 60 -670 100 { lab=Dis1_S}
N -670 160 -670 180 { lab=GND}
N -630 90 -630 130 { lab=Dis2_S}
N -630 190 -630 210 { lab=GND}
N -590 120 -590 160 { lab=Dis3_S}
N -590 220 -590 240 { lab=GND}
N -670 -130 -670 -90 { lab=CLK1_S}
N -670 -30 -670 -10 { lab=GND}
N -630 -100 -630 -60 { lab=CLK2_S}
N -630 0 -630 20 { lab=GND}
N -590 -70 -590 -30 { lab=CLK3_S}
N -590 30 -590 50 { lab=GND}
N -770 -1100 -770 -1060 { lab=CLK0}
N -770 -1000 -770 -980 { lab=GND}
N -770 -910 -770 -870 { lab=Dis0}
N -770 -810 -770 -790 { lab=GND}
N -730 -880 -730 -840 { lab=Dis1}
N -730 -780 -730 -760 { lab=GND}
N -690 -850 -690 -810 { lab=Dis2}
N -690 -750 -690 -730 { lab=GND}
N -650 -820 -650 -780 { lab=Dis3}
N -650 -720 -650 -700 { lab=GND}
N -730 -1070 -730 -1030 { lab=CLK1}
N -730 -970 -730 -950 { lab=GND}
N -690 -1040 -690 -1000 { lab=CLK2}
N -690 -940 -690 -920 { lab=GND}
N -650 -1010 -650 -970 { lab=CLK3}
N -650 -910 -650 -890 { lab=GND}
N -770 -590 -770 -570 { lab=x0_bar}
N -770 -510 -770 -490 { lab=GND}
N -740 -560 -740 -540 { lab=x0}
N -740 -480 -740 -460 { lab=GND}
N -710 -530 -710 -510 { lab=x1_bar}
N -710 -450 -710 -430 { lab=GND}
N -680 -500 -680 -480 { lab=x1}
N -680 -430 -680 -410 { lab=GND}
N -650 -470 -650 -450 { lab=x2_bar}
N -650 -390 -650 -370 { lab=GND}
N -620 -440 -620 -420 { lab=x2}
N -620 -360 -620 -340 { lab=GND}
N -590 -410 -590 -390 { lab=x3_bar}
N -590 -330 -590 -310 { lab=GND}
N -560 -380 -560 -360 { lab=x3}
N -560 -300 -560 -280 { lab=GND}
N 260 -930 280 -930 { lab=x0}
N 260 -910 280 -910 { lab=x0_bar}
N 260 -890 280 -890 { lab=x3}
N 260 -870 280 -870 { lab=x3_bar}
N 260 -850 280 -850 { lab=Dis0}
N 260 -830 280 -830 { lab=CLK0}
N 260 -780 280 -780 { lab=x1}
N 260 -760 280 -760 { lab=x1_bar}
N 260 -740 280 -740 { lab=x2_bar}
N 260 -720 280 -720 { lab=x2}
N 260 -700 280 -700 { lab=Dis0}
N 260 -680 280 -680 { lab=CLK0}
N 260 -620 280 -620 { lab=x2}
N 260 -600 280 -600 { lab=x2_bar}
N 260 -580 280 -580 { lab=x1_bar}
N 260 -560 280 -560 { lab=x1}
N 260 -540 280 -540 { lab=Dis0}
N 260 -520 280 -520 { lab=CLK0}
N 580 -930 600 -930 { lab=XOR1}
N 580 -910 600 -910 { lab=XNOR1}
N 580 -780 600 -780 { lab=OR1}
N 580 -760 600 -760 { lab=NOR1}
N 580 -620 600 -620 { lab=AND1}
N 580 -600 600 -600 { lab=NAND1}
N 600 -930 740 -930 { lab=XOR1}
N 740 -930 740 -880 { lab=XOR1}
N 740 -880 780 -880 { lab=XOR1}
N 600 -910 710 -910 { lab=XNOR1}
N 710 -910 710 -860 { lab=XNOR1}
N 710 -860 780 -860 { lab=XNOR1}
N 750 -780 780 -780 { lab=CLK1}
N 750 -800 780 -800 { lab=Dis1}
N 600 -840 600 -780 { lab=OR1}
N 600 -840 780 -840 { lab=OR1}
N 600 -760 620 -760 { lab=NOR1}
N 620 -820 620 -760 { lab=NOR1}
N 620 -820 780 -820 { lab=NOR1}
N 730 -860 730 -660 { lab=XNOR1}
N 730 -660 780 -660 { lab=XNOR1}
N 720 -930 720 -640 { lab=XOR1}
N 720 -640 780 -640 { lab=XOR1}
N 600 -620 780 -620 { lab=AND1}
N 600 -600 780 -600 { lab=NAND1}
N 750 -580 780 -580 { lab=Dis1}
N 750 -560 780 -560 { lab=CLK1}
N 1080 -880 1110 -880 { lab=AND2}
N 1080 -860 1110 -860 { lab=NAND2}
N 1080 -660 1110 -660 { lab=AND3}
N 1080 -640 1110 -640 { lab=NAND3}
N 1240 -690 1270 -690 { lab=CLK2}
N 1240 -710 1270 -710 { lab=Dis2}
N 1110 -880 1220 -880 { lab=AND2}
N 1220 -880 1220 -790 { lab=AND2}
N 1220 -790 1270 -790 { lab=AND2}
N 1110 -860 1200 -860 { lab=NAND2}
N 1200 -860 1200 -780 { lab=NAND2}
N 1200 -780 1200 -770 { lab=NAND2}
N 1200 -770 1270 -770 { lab=NAND2}
N 1110 -660 1160 -660 { lab=AND3}
N 1160 -750 1160 -660 { lab=AND3}
N 1160 -750 1270 -750 { lab=AND3}
N 1110 -640 1180 -640 { lab=NAND3}
N 1180 -730 1180 -640 { lab=NAND3}
N 1180 -730 1270 -730 { lab=NAND3}
N 1570 -790 1600 -790 { lab=s0}
N 1570 -770 1600 -770 { lab=s0_bar}
N 1570 -750 1590 -750 { lab=GND}
N 1080 -620 1110 -620 { lab=GND}
N 1080 -840 1110 -840 { lab=GND}
N 580 -580 610 -580 { lab=GND}
N 580 -740 610 -740 { lab=GND}
N 580 -890 610 -890 { lab=GND}
N 1610 -750 1610 -730 { lab=GND}
N 1600 -750 1610 -750 { lab=GND}
N 260 -1300 280 -1300 { lab=x0_S}
N 260 -1280 280 -1280 { lab=x0_bar_S}
N 260 -1180 280 -1180 { lab=x3_S}
N 260 -1160 280 -1160 { lab=x3_bar_S}
N 260 -1140 280 -1140 { lab=Dis0_S}
N 260 -1260 280 -1260 { lab=x1_S}
N 260 -1240 280 -1240 { lab=x1_bar_S}
N 260 -1200 280 -1200 { lab=x2_bar_S}
N 260 -1220 280 -1220 { lab=x2_S}
N 580 -1300 610 -1300 { lab=s0_flat}
N 580 -1280 610 -1280 { lab=s0_bar_flat}
N 260 -1120 280 -1120 { lab=Dis1_S}
N 260 -1100 280 -1100 { lab=Dis2_S}
N 260 -1080 280 -1080 { lab=CLK0_S}
N 260 -1060 280 -1060 { lab=CLK1_S}
N 260 -1040 280 -1040 { lab=CLK2_S}
N 260 -1710 280 -1710 { lab=x0_S}
N 260 -1690 280 -1690 { lab=x0_bar_S}
N 260 -1470 280 -1470 { lab=x3_S}
N 260 -1450 280 -1450 { lab=x3_bar_S}
N 260 -1390 280 -1390 { lab=Dis0_S}
N 260 -1630 280 -1630 { lab=x1_S}
N 260 -1610 280 -1610 { lab=x1_bar_S}
N 260 -1530 280 -1530 { lab=x2_bar_S}
N 260 -1550 280 -1550 { lab=x2_S}
N 580 -1710 610 -1710 { lab=XOR0_S}
N 580 -1690 610 -1690 { lab=XOR0_bar_S}
N 260 -1370 280 -1370 { lab=CLK0_S}
N 580 -1670 610 -1670 { lab=XOR1_S}
N 580 -1650 610 -1650 { lab=XOR1_bar_S}
N 580 -1630 610 -1630 { lab=XOR2_S}
N 580 -1610 610 -1610 { lab=XOR2_bar_S}
N 580 -1590 610 -1590 { lab=XOR3_S}
N 580 -1570 610 -1570 { lab=XOR3_bar_S}
N 260 -1670 280 -1670 { lab=k0_S}
N 260 -1650 280 -1650 { lab=k0_bar_S}
N 260 -1590 280 -1590 { lab=k1_S}
N 260 -1570 280 -1570 { lab=k1_bar_S}
N 260 -1510 280 -1510 { lab=k2_S}
N 260 -1490 280 -1490 { lab=k2_bar_S}
N 260 -1430 280 -1430 { lab=k3_S}
N 260 -1410 280 -1410 { lab=k3_bar_S}
N 970 -1050 990 -1050 { lab=Dis0_S}
N 970 -1030 990 -1030 { lab=CLK0_S}
N 970 -1200 990 -1200 { lab=Dis0_S}
N 970 -1180 990 -1180 { lab=CLK0_S}
N 970 -1350 990 -1350 { lab=Dis0_S}
N 970 -1330 990 -1330 { lab=CLK0_S}
N 970 -1500 990 -1500 { lab=Dis0_S}
N 970 -1480 990 -1480 { lab=CLK0_S}
N 970 -1580 990 -1580 { lab=x0_S}
N 970 -1560 990 -1560 { lab=x0_bar_S}
N 970 -1540 990 -1540 { lab=k0_S}
N 970 -1520 990 -1520 { lab=k0_bar_S}
N 970 -1430 990 -1430 { lab=x1_S}
N 970 -1410 990 -1410 { lab=x1_bar_S}
N 970 -1390 990 -1390 { lab=k1_S}
N 970 -1370 990 -1370 { lab=k1_bar_S}
N 970 -1260 990 -1260 { lab=x2_bar_S}
N 970 -1280 990 -1280 { lab=x2_S}
N 970 -1240 990 -1240 { lab=k2_S}
N 970 -1220 990 -1220 { lab=k2_bar_S}
N 970 -1130 990 -1130 { lab=x3_S}
N 970 -1110 990 -1110 { lab=x3_bar_S}
N 970 -1090 990 -1090 { lab=k3_S}
N 970 -1070 990 -1070 { lab=k3_bar_S}
N 1290 -1580 1320 -1580 { lab=XOR0_S}
N 1290 -1560 1320 -1560 { lab=XOR0_bar_S}
N 1290 -1430 1320 -1430 { lab=XOR1_S}
N 1290 -1410 1320 -1410 { lab=XOR1_bar_S}
N 1290 -1280 1320 -1280 { lab=XOR2_S}
N 1290 -1260 1320 -1260 { lab=XOR2_bar_S}
N 1290 -1130 1320 -1130 { lab=XOR3_S}
N 1290 -1110 1320 -1110 { lab=XOR3_bar_S}
N 640 -2160 750 -2160 { lab=XOR0_S}
N 640 -2140 750 -2140 { lab=XOR0_bar_S}
N 640 -2120 750 -2120 { lab=XOR1_S}
N 640 -2100 750 -2100 { lab=XOR1_bar_S}
N 640 -2080 750 -2080 { lab=XOR2_S}
N 640 -2060 750 -2060 { lab=XOR2_bar_S}
N 640 -2040 750 -2040 { lab=XOR3_S}
N 640 -2020 750 -2020 { lab=XOR3_bar_S}
N 320 -2160 340 -2160 { lab=x0_S}
N 320 -2140 340 -2140 { lab=x0_bar_S}
N 320 -1920 340 -1920 { lab=x3_S}
N 320 -1900 340 -1900 { lab=x3_bar_S}
N 320 -1840 340 -1840 { lab=Dis0_S}
N 320 -2080 340 -2080 { lab=x1_S}
N 320 -2060 340 -2060 { lab=x1_bar_S}
N 320 -1980 340 -1980 { lab=x2_bar_S}
N 320 -2000 340 -2000 { lab=x2_S}
N 320 -1820 340 -1820 { lab=CLK0_S}
N 320 -2120 340 -2120 { lab=k0_S}
N 320 -2100 340 -2100 { lab=k0_bar_S}
N 320 -2040 340 -2040 { lab=k1_S}
N 320 -2020 340 -2020 { lab=k1_bar_S}
N 320 -1960 340 -1960 { lab=k2_S}
N 320 -1940 340 -1940 { lab=k2_bar_S}
N 320 -1880 340 -1880 { lab=k3_S}
N 320 -1860 340 -1860 { lab=k3_bar_S}
N 730 -2000 750 -2000 { lab=Dis1_S}
N 730 -1980 750 -1980 { lab=Dis2_S}
N 730 -1960 750 -1960 { lab=Dis3_S}
N 730 -1940 750 -1940 { lab=CLK1_S}
N 730 -1920 750 -1920 { lab=CLK2_S}
N 730 -1900 750 -1900 { lab=CLK3_S}
N 1050 -2160 1070 -2160 { lab=s0_norm}
N 1050 -2140 1070 -2140 { lab=s0_bar_norm}
N 1050 -2120 1070 -2120 { lab=s1_norm}
N 1050 -2100 1070 -2100 { lab=s1_bar_norm}
N 1050 -2080 1070 -2080 { lab=s2_norm}
N 1050 -2060 1070 -2060 { lab=s2_bar_norm}
N 1050 -2040 1070 -2040 { lab=s3_norm}
N 1050 -2020 1070 -2020 { lab=s3_bar_norm}
N 610 -2730 630 -2730 { lab=s0_norm}
N 610 -2710 630 -2710 { lab=s0_bar_norm}
N 610 -2690 630 -2690 { lab=s1_norm}
N 610 -2670 630 -2670 { lab=s1_bar_norm}
N 610 -2650 630 -2650 { lab=s2_norm}
N 610 -2630 630 -2630 { lab=s2_bar_norm}
N 610 -2610 630 -2610 { lab=s3_norm}
N 610 -2590 630 -2590 { lab=s3_bar_norm}
N 290 -2730 310 -2730 { lab=x0_S}
N 290 -2710 310 -2710 { lab=x0_bar_S}
N 290 -2490 310 -2490 { lab=x3_S}
N 290 -2470 310 -2470 { lab=x3_bar_S}
N 290 -2410 310 -2410 { lab=Dis0_S}
N 290 -2650 310 -2650 { lab=x1_S}
N 290 -2630 310 -2630 { lab=x1_bar_S}
N 290 -2550 310 -2550 { lab=x2_bar_S}
N 290 -2570 310 -2570 { lab=x2_S}
N 290 -2690 310 -2690 { lab=k0_S}
N 290 -2670 310 -2670 { lab=k0_bar_S}
N 290 -2610 310 -2610 { lab=k1_S}
N 290 -2590 310 -2590 { lab=k1_bar_S}
N 290 -2530 310 -2530 { lab=k2_S}
N 290 -2510 310 -2510 { lab=k2_bar_S}
N 290 -2450 310 -2450 { lab=k3_S}
N 290 -2430 310 -2430 { lab=k3_bar_S}
N 290 -2390 310 -2390 { lab=Dis1_S}
N 290 -2370 310 -2370 { lab=Dis2_S}
N 290 -2350 310 -2350 { lab=Dis3_S}
N 290 -2310 310 -2310 { lab=CLK1_S}
N 290 -2290 310 -2290 { lab=CLK2_S}
N 290 -2270 310 -2270 { lab=CLK3_S}
N 290 -2330 310 -2330 { lab=CLK0_S}
N -1280 -550 -1280 -530 { lab=x0_bar_S}
N -1280 -470 -1280 -450 { lab=GND}
N -1250 -520 -1250 -500 { lab=x0_S}
N -1250 -440 -1250 -420 { lab=GND}
N -1220 -490 -1220 -470 { lab=x1_bar_S}
N -1220 -410 -1220 -390 { lab=GND}
N -1190 -460 -1190 -440 { lab=x1_S}
N -1190 -390 -1190 -370 { lab=GND}
N -1160 -430 -1160 -410 { lab=x2_bar_S}
N -1160 -350 -1160 -330 { lab=GND}
N -1130 -400 -1130 -380 { lab=x2_S}
N -1130 -320 -1130 -300 { lab=GND}
N -1100 -370 -1100 -350 { lab=x3_bar_S}
N -1100 -290 -1100 -270 { lab=GND}
N -1070 -340 -1070 -320 { lab=x3_S}
N -1070 -260 -1070 -240 { lab=GND}
N 892.5 -2742.5 912.5 -2742.5 { lab=x0_S}
N 892.5 -2722.5 912.5 -2722.5 { lab=x0_bar_S}
N 892.5 -2502.5 912.5 -2502.5 { lab=x3_S}
N 892.5 -2482.5 912.5 -2482.5 { lab=x3_bar_S}
N 892.5 -2422.5 912.5 -2422.5 { lab=Dis0_S}
N 892.5 -2662.5 912.5 -2662.5 { lab=x1_S}
N 892.5 -2642.5 912.5 -2642.5 { lab=x1_bar_S}
N 892.5 -2562.5 912.5 -2562.5 { lab=x2_bar_S}
N 892.5 -2582.5 912.5 -2582.5 { lab=x2_S}
N 892.5 -2702.5 912.5 -2702.5 { lab=k0_S}
N 892.5 -2682.5 912.5 -2682.5 { lab=k0_bar_S}
N 892.5 -2622.5 912.5 -2622.5 { lab=k1_S}
N 892.5 -2602.5 912.5 -2602.5 { lab=k1_bar_S}
N 892.5 -2542.5 912.5 -2542.5 { lab=k2_S}
N 892.5 -2522.5 912.5 -2522.5 { lab=k2_bar_S}
N 892.5 -2462.5 912.5 -2462.5 { lab=k3_S}
N 892.5 -2442.5 912.5 -2442.5 { lab=k3_bar_S}
N 892.5 -2402.5 912.5 -2402.5 { lab=Dis1_S}
N 892.5 -2382.5 912.5 -2382.5 { lab=Dis2_S}
N 892.5 -2362.5 912.5 -2362.5 { lab=Dis3_S}
N 892.5 -2322.5 912.5 -2322.5 { lab=CLK1_S}
N 892.5 -2302.5 912.5 -2302.5 { lab=CLK2_S}
N 892.5 -2282.5 912.5 -2282.5 { lab=CLK3_S}
N 892.5 -2342.5 912.5 -2342.5 { lab=CLK0_S}
N 1212.5 -2742.5 1232.5 -2742.5 { lab=s0_flat}
N 1212.5 -2722.5 1232.5 -2722.5 { lab=s0_bar_flat}
N 1212.5 -2702.5 1232.5 -2702.5 { lab=s1_flat}
N 1212.5 -2682.5 1232.5 -2682.5 { lab=s1_bar_flat}
N 1212.5 -2662.5 1232.5 -2662.5 { lab=s2_flat}
N 1212.5 -2642.5 1232.5 -2642.5 { lab=s2_bar_flat}
N 1212.5 -2622.5 1232.5 -2622.5 { lab=s3_flat}
N 1212.5 -2602.5 1232.5 -2602.5 { lab=s3_bar_flat}
N -710 670 -710 690 { lab=x0_bar_S}
N -710 750 -710 770 { lab=GND}
N -680 700 -680 720 { lab=x0_S}
N -680 780 -680 800 { lab=GND}
N -650 730 -650 750 { lab=x1_bar_S}
N -650 810 -650 830 { lab=GND}
N -620 760 -620 780 { lab=x1_S}
N -620 830 -620 850 { lab=GND}
N -590 790 -590 810 { lab=x2_bar_S}
N -590 870 -590 890 { lab=GND}
N -560 820 -560 840 { lab=x2_S}
N -560 900 -560 920 { lab=GND}
N -530 850 -530 870 { lab=x3_bar_S}
N -530 930 -530 950 { lab=GND}
N -500 880 -500 900 { lab=x3_S}
N -500 960 -500 980 { lab=GND}
N -620 1000 -620 1020 { lab=k0_S}
N -540 1060 -540 1080 { lab=k2_S}
N -500 1090 -500 1110 { lab=k3_S}
N -580 1030 -580 1050 { lab=k1_S}
N -630 1220 -630 1240 { lab=k0_bar_S}
N -550 1280 -550 1300 { lab=k2_bar_S}
N -510 1310 -510 1330 { lab=k3_bar_S}
N -590 1250 -590 1270 { lab=k1_bar_S}
N -1150 1030 -1150 1050 { lab=k0_S}
N -1030 1150 -1030 1170 { lab=k2_S}
N -970 1210 -970 1230 { lab=k3_S}
N -1090 1090 -1090 1110 { lab=k1_S}
N -1180 1000 -1180 1020 { lab=k0_bar_S}
N -1060 1120 -1060 1140 { lab=k2_bar_S}
N -1000 1180 -1000 1200 { lab=k3_bar_S}
N -1120 1060 -1120 1080 { lab=k1_bar_S}
N -1110 700 -1110 720 { lab=x1_bar_S}
N -1080 730 -1080 750 { lab=x1_S}
N -1170 640 -1170 660 { lab=x0_bar_S}
N -1170 720 -1170 740 { lab=GND}
N -1140 670 -1140 690 { lab=x0_S}
N -1140 750 -1140 770 { lab=GND}
N -1110 780 -1110 800 { lab=GND}
N -1050 760 -1050 780 { lab=x2_bar_S}
N -1020 790 -1020 810 { lab=x2_S}
N -1050 840 -1050 860 { lab=GND}
N -1020 860 -1020 880 { lab=GND}
N -990 820 -990 840 { lab=x3_bar_S}
N -960 850 -960 870 { lab=x3_S}
N -990 900 -990 920 { lab=GND}
N -1080 810 -1080 820 { lab=GND}
N -960 930 -960 940 { lab=GND}
N -660 1920 -660 1940 { lab=k0_S}
N -560 1920 -560 1940 { lab=k2_S}
N -520 1920 -520 1940 { lab=k3_S}
N -610 1920 -610 1940 { lab=k1_S}
N -660 2110 -660 2130 { lab=k0_bar_S}
N -560 2110 -560 2130 { lab=k2_bar_S}
N -510 2110 -510 2130 { lab=k3_bar_S}
N -610 2110 -610 2130 { lab=k1_bar_S}
N -620 1750 -620 1770 { lab=x1_bar_S}
N -620 1540 -620 1560 { lab=x1_S}
N -690 1750 -690 1770 { lab=x0_bar_S}
N -690 1830 -690 1850 { lab=GND}
N -690 1540 -690 1560 { lab=x0_S}
N -690 1620 -690 1640 { lab=GND}
N -620 1830 -620 1850 { lab=GND}
N -560 1750 -560 1770 { lab=x2_bar_S}
N -560 1540 -560 1560 { lab=x2_S}
N -560 1830 -560 1850 { lab=GND}
N -560 1610 -560 1630 { lab=GND}
N -490 1750 -490 1770 { lab=x3_bar_S}
N -490 1540 -490 1560 { lab=x3_S}
N -490 1830 -490 1850 { lab=GND}
N -620 1620 -620 1630 { lab=GND}
N -490 1620 -490 1630 { lab=GND}
N 260 800 340 800 { lab=x4_S}
N 260 820 340 820 { lab=x4_bar_S}
N 260 840 340 840 { lab=k4_S}
N 260 860 340 860 { lab=k4_bar_S}
N 260 880 340 880 { lab=x5_S}
N 260 900 340 900 { lab=x5_bar_S}
N 260 920 340 920 { lab=k5_S}
N 260 940 340 940 { lab=k5_bar_S}
N 260 960 340 960 { lab=x6_S}
N 260 980 340 980 { lab=x6_bar_S}
N 260 1000 340 1000 { lab=k6_S}
N 260 1020 340 1020 { lab=k6_bar_S}
N 260 1040 340 1040 { lab=x7_S}
N 260 1060 340 1060 { lab=x7_bar_S}
N 260 1080 340 1080 { lab=k7_S}
N 260 1100 340 1100 { lab=k7_bar_S}
N 260 1120 340 1120 { lab=Dis0_S}
N 260 1140 340 1140 { lab=Dis1_S}
N 260 1160 340 1160 { lab=Dis2_S}
N 260 1180 340 1180 { lab=Dis3_S}
N 260 1200 340 1200 { lab=CLK0_S}
N 260 1220 340 1220 { lab=CLK1_S}
N 260 1240 340 1240 { lab=CLK2_S}
N 260 1260 340 1260 { lab=CLK3_S}
N 580 1460 660 1460 { lab=x8_S}
N 580 1480 660 1480 { lab=x8_bar_S}
N 580 1500 660 1500 { lab=k8_S}
N 580 1520 660 1520 { lab=k8_bar_S}
N 580 1540 660 1540 { lab=x9_S}
N 580 1560 660 1560 { lab=x9_bar_S}
N 580 1580 660 1580 { lab=k9_S}
N 580 1600 660 1600 { lab=k9_bar_S}
N 580 1620 660 1620 { lab=x10_S}
N 580 1640 660 1640 { lab=x10_bar_S}
N 580 1660 660 1660 { lab=k10_S}
N 580 1680 660 1680 { lab=k10_bar_S}
N 580 1700 660 1700 { lab=x11_S}
N 580 1720 660 1720 { lab=x11_bar_S}
N 580 1740 660 1740 { lab=k11_S}
N 580 1760 660 1760 { lab=k11_bar_S}
N 580 1780 660 1780 { lab=Dis0_S}
N 580 1800 660 1800 { lab=Dis1_S}
N 580 1820 660 1820 { lab=Dis2_S}
N 580 1840 660 1840 { lab=Dis3_S}
N 580 1860 660 1860 { lab=CLK0_S}
N 580 1880 660 1880 { lab=CLK1_S}
N 580 1900 660 1900 { lab=CLK2_S}
N 580 1920 660 1920 { lab=CLK3_S}
N 960 1460 1180 1460 { lab=s8_norm}
N 960 1480 1180 1480 { lab=s8_norm_bar}
N 960 1500 1180 1500 { lab=s9_norm}
N 960 1520 1180 1520 { lab=s9_norm_bar}
N 960 1540 1180 1540 { lab=s10_norm}
N 960 1560 1180 1560 { lab=s10_norm_bar}
N 960 1580 1180 1580 { lab=s11_norm}
N 960 1600 1180 1600 { lab=s11_norm_bar}
N 1180 1460 1210 1460 { lab=s8_norm}
N 1180 1480 1210 1480 { lab=s8_norm_bar}
N 1180 1500 1210 1500 { lab=s9_norm}
N 1180 1520 1210 1520 { lab=s9_norm_bar}
N 1180 1540 1210 1540 { lab=s10_norm}
N 1180 1560 1210 1560 { lab=s10_norm_bar}
N 1180 1580 1210 1580 { lab=s11_norm}
N 1180 1600 1210 1600 { lab=s11_norm_bar}
N 980 1420 980 1460 { lab=s8_norm}
N 1010 1420 1010 1480 { lab=s8_norm_bar}
N 1040 1420 1040 1500 { lab=s9_norm}
N 1070 1420 1070 1520 { lab=s9_norm_bar}
N 1100 1420 1100 1540 { lab=s10_norm}
N 1130 1420 1130 1560 { lab=s10_norm_bar}
N 1160 1420 1160 1580 { lab=s11_norm}
N 1190 1420 1190 1600 { lab=s11_norm_bar}
N 580 2020 660 2020 { lab=x12_S}
N 580 2040 660 2040 { lab=x12_bar_S}
N 580 2060 660 2060 { lab=k12_S}
N 580 2080 660 2080 { lab=k12_bar_S}
N 580 2100 660 2100 { lab=x13_S}
N 580 2120 660 2120 { lab=x13_bar_S}
N 580 2140 660 2140 { lab=k13_S}
N 580 2160 660 2160 { lab=k13_bar_S}
N 580 2180 660 2180 { lab=x14_S}
N 580 2200 660 2200 { lab=x14_bar_S}
N 580 2220 660 2220 { lab=k14_S}
N 580 2240 660 2240 { lab=k14_bar_S}
N 580 2260 660 2260 { lab=x15_S}
N 580 2280 660 2280 { lab=x15_bar_S}
N 580 2300 660 2300 { lab=k15_S}
N 580 2320 660 2320 { lab=k15_bar_S}
N 580 2340 660 2340 { lab=Dis0_S}
N 580 2360 660 2360 { lab=Dis1_S}
N 580 2380 660 2380 { lab=Dis2_S}
N 580 2400 660 2400 { lab=Dis3_S}
N 580 2420 660 2420 { lab=CLK0_S}
N 580 2440 660 2440 { lab=CLK1_S}
N 580 2460 660 2460 { lab=CLK2_S}
N 960 2020 1180 2020 { lab=s12_norm}
N 960 2040 1180 2040 { lab=s12_norm_bar}
N 960 2060 1180 2060 { lab=s13_norm}
N 960 2080 1180 2080 { lab=s13_norm_bar}
N 960 2100 1180 2100 { lab=s14_norm}
N 960 2120 1180 2120 { lab=s14_norm_bar}
N 960 2140 1180 2140 { lab=s15_norm}
N 960 2160 1180 2160 { lab=s15_norm_bar}
N 1180 2020 1210 2020 { lab=s12_norm}
N 1180 2040 1210 2040 { lab=s12_norm_bar}
N 1180 2060 1210 2060 { lab=s13_norm}
N 1180 2080 1210 2080 { lab=s13_norm_bar}
N 1180 2100 1210 2100 { lab=s14_norm}
N 1180 2120 1210 2120 { lab=s14_norm_bar}
N 1180 2140 1210 2140 { lab=s15_norm}
N 1180 2160 1210 2160 { lab=s15_norm_bar}
N 980 1980 980 2020 { lab=s12_norm}
N 1010 1980 1010 2040 { lab=s12_norm_bar}
N 1040 1980 1040 2060 { lab=s13_norm}
N 1070 1980 1070 2080 { lab=s13_norm_bar}
N 1100 1980 1100 2100 { lab=s14_norm}
N 1130 1980 1130 2120 { lab=s14_norm_bar}
N 1160 1980 1160 2140 { lab=s15_norm}
N 1190 1980 1190 2160 { lab=s15_norm_bar}
N 580 2480 660 2480 { lab=CLK3_S}
N 580 2570 660 2570 { lab=x16_S}
N 580 2590 660 2590 { lab=x16_S_bar}
N 580 2610 660 2610 { lab=k16_S}
N 580 2630 660 2630 { lab=k16_S_bar}
N 580 2650 660 2650 { lab=x17_S}
N 580 2670 660 2670 { lab=x17_S_bar}
N 580 2690 660 2690 { lab=k17_S}
N 580 2710 660 2710 { lab=k17_S_bar}
N 580 2730 660 2730 { lab=x18_S}
N 580 2750 660 2750 { lab=x18_S_bar}
N 580 2770 660 2770 { lab=k18_S}
N 580 2790 660 2790 { lab=k18_S_bar}
N 580 2810 660 2810 { lab=x19_S}
N 580 2830 660 2830 { lab=x19_S_bar}
N 580 2850 660 2850 { lab=k19_S}
N 580 2870 660 2870 { lab=k19_S_bar}
N 580 2890 660 2890 { lab=Dis0_S}
N 580 2910 660 2910 { lab=Dis1_S}
N 580 2930 660 2930 { lab=Dis2_S}
N 580 2950 660 2950 { lab=Dis3_S}
N 580 2970 660 2970 { lab=CLK0_S}
N 580 2990 660 2990 { lab=CLK1_S}
N 580 3010 660 3010 { lab=CLK2_S}
N 580 3030 660 3030 { lab=CLK3_S}
N 960 2570 1180 2570 { lab=s16_norm}
N 960 2590 1180 2590 { lab=s16_norm_bar}
N 960 2610 1180 2610 { lab=s17_norm}
N 960 2630 1180 2630 { lab=s17_norm_bar}
N 960 2650 1180 2650 { lab=s18_norm}
N 960 2670 1180 2670 { lab=s18_norm_bar}
N 960 2690 1180 2690 { lab=s19_norm}
N 960 2710 1180 2710 { lab=s19_norm_bar}
N 1180 2570 1210 2570 { lab=s16_norm}
N 1180 2590 1210 2590 { lab=s16_norm_bar}
N 1180 2610 1210 2610 { lab=s17_norm}
N 1180 2630 1210 2630 { lab=s17_norm_bar}
N 1180 2650 1210 2650 { lab=s18_norm}
N 1180 2670 1210 2670 { lab=s18_norm_bar}
N 1180 2690 1210 2690 { lab=s19_norm}
N 1180 2710 1210 2710 { lab=s19_norm_bar}
N 980 2530 980 2570 { lab=s16_norm}
N 1010 2530 1010 2590 { lab=s16_norm_bar}
N 1040 2530 1040 2610 { lab=s17_norm}
N 1070 2530 1070 2630 { lab=s17_norm_bar}
N 1100 2530 1100 2650 { lab=s18_norm}
N 1130 2530 1130 2670 { lab=s18_norm_bar}
N 1160 2530 1160 2690 { lab=s19_norm}
N 1190 2530 1190 2710 { lab=s19_norm_bar}
N 580 3120 660 3120 { lab=x20_S}
N 580 3140 660 3140 { lab=x20_S_bar}
N 580 3160 660 3160 { lab=k20_S}
N 580 3180 660 3180 { lab=k20_S_bar}
N 580 3200 660 3200 { lab=x21_S}
N 580 3220 660 3220 { lab=x21_S_bar}
N 580 3240 660 3240 { lab=k21_S}
N 580 3260 660 3260 { lab=k21_S_bar}
N 580 3280 660 3280 { lab=x22_S}
N 580 3300 660 3300 { lab=x22_S_bar}
N 580 3320 660 3320 { lab=k22_S}
N 580 3340 660 3340 { lab=k22_S_bar}
N 580 3360 660 3360 { lab=x23_S}
N 580 3380 660 3380 { lab=x23_S_bar}
N 580 3400 660 3400 { lab=k23_S}
N 580 3420 660 3420 { lab=k23_S_bar}
N 580 3440 660 3440 { lab=Dis0_S}
N 580 3460 660 3460 { lab=Dis1_S}
N 580 3480 660 3480 { lab=Dis2_S}
N 580 3500 660 3500 { lab=Dis3_S}
N 580 3520 660 3520 { lab=CLK0_S}
N 580 3540 660 3540 { lab=CLK1_S}
N 580 3560 660 3560 { lab=CLK2_S}
N 580 3580 660 3580 { lab=CLK3_S}
N 960 3120 1180 3120 { lab=s20_norm}
N 960 3140 1180 3140 { lab=s20_norm_bar}
N 960 3160 1180 3160 { lab=s21_norm}
N 960 3180 1180 3180 { lab=s21_norm_bar}
N 960 3200 1180 3200 { lab=s22_norm}
N 960 3220 1180 3220 { lab=s22_norm_bar}
N 960 3240 1180 3240 { lab=s23_norm}
N 960 3260 1180 3260 { lab=s23_norm_bar}
N 1180 3120 1210 3120 { lab=s20_norm}
N 1180 3140 1210 3140 { lab=s20_norm_bar}
N 1180 3160 1210 3160 { lab=s21_norm}
N 1180 3180 1210 3180 { lab=s21_norm_bar}
N 1180 3200 1210 3200 { lab=s22_norm}
N 1180 3220 1210 3220 { lab=s22_norm_bar}
N 1180 3240 1210 3240 { lab=s23_norm}
N 1180 3260 1210 3260 { lab=s23_norm_bar}
N 980 3080 980 3120 { lab=s20_norm}
N 1010 3080 1010 3140 { lab=s20_norm_bar}
N 1040 3080 1040 3160 { lab=s21_norm}
N 1070 3080 1070 3180 { lab=s21_norm_bar}
N 1100 3080 1100 3200 { lab=s22_norm}
N 1130 3080 1130 3220 { lab=s22_norm_bar}
N 1160 3080 1160 3240 { lab=s23_norm}
N 1190 3080 1190 3260 { lab=s23_norm_bar}
N 580 3670 660 3670 { lab=x24_S}
N 580 3690 660 3690 { lab=x24_S_bar}
N 580 3710 660 3710 { lab=k24_S}
N 580 3730 660 3730 { lab=k24_S_bar}
N 580 3750 660 3750 { lab=x25_S}
N 580 3770 660 3770 { lab=x25_S_bar}
N 580 3790 660 3790 { lab=k25_S}
N 580 3810 660 3810 { lab=k25_S_bar}
N 580 3830 660 3830 { lab=x26_S}
N 580 3850 660 3850 { lab=x26_S_bar}
N 580 3870 660 3870 { lab=k26_S}
N 580 3890 660 3890 { lab=k26_S_bar}
N 580 3910 660 3910 { lab=x27_S}
N 580 3930 660 3930 { lab=x27_S_bar}
N 580 3950 660 3950 { lab=k27_S}
N 580 3970 660 3970 { lab=k27_S_bar}
N 580 3990 660 3990 { lab=Dis0_S}
N 580 4010 660 4010 { lab=Dis1_S}
N 580 4030 660 4030 { lab=Dis2_S}
N 580 4050 660 4050 { lab=Dis3_S}
N 580 4070 660 4070 { lab=CLK0_S}
N 580 4090 660 4090 { lab=CLK1_S}
N 580 4110 660 4110 { lab=CLK2_S}
N 580 4130 660 4130 { lab=CLK3_S}
N 960 3670 1180 3670 { lab=s24_norm}
N 960 3690 1180 3690 { lab=s24_norm_bar}
N 960 3710 1180 3710 { lab=s25_norm}
N 960 3730 1180 3730 { lab=s25_norm_bar}
N 960 3750 1180 3750 { lab=s26_norm}
N 960 3770 1180 3770 { lab=s26_norm_bar}
N 960 3790 1180 3790 { lab=s27_norm}
N 960 3810 1180 3810 { lab=s27_norm_bar}
N 1180 3670 1210 3670 { lab=s24_norm}
N 1180 3690 1210 3690 { lab=s24_norm_bar}
N 1180 3710 1210 3710 { lab=s25_norm}
N 1180 3730 1210 3730 { lab=s25_norm_bar}
N 1180 3750 1210 3750 { lab=s26_norm}
N 1180 3770 1210 3770 { lab=s26_norm_bar}
N 1180 3790 1210 3790 { lab=s27_norm}
N 1180 3810 1210 3810 { lab=s27_norm_bar}
N 980 3630 980 3670 { lab=s24_norm}
N 1010 3630 1010 3690 { lab=s24_norm_bar}
N 1040 3630 1040 3710 { lab=s25_norm}
N 1070 3630 1070 3730 { lab=s25_norm_bar}
N 1100 3630 1100 3750 { lab=s26_norm}
N 1130 3630 1130 3770 { lab=s26_norm_bar}
N 1160 3630 1160 3790 { lab=s27_norm}
N 1190 3630 1190 3810 { lab=s27_norm_bar}
N 580 4220 660 4220 { lab=x28_S}
N 580 4240 660 4240 { lab=x28_S_bar}
N 580 4260 660 4260 { lab=k28_S}
N 580 4280 660 4280 { lab=k28_S_bar}
N 580 4300 660 4300 { lab=x29_S}
N 580 4320 660 4320 { lab=x29_S_bar}
N 580 4340 660 4340 { lab=k29_S}
N 580 4360 660 4360 { lab=k29_S_bar}
N 580 4380 660 4380 { lab=x30_S}
N 580 4400 660 4400 { lab=x30_S_bar}
N 580 4420 660 4420 { lab=k30_S}
N 580 4440 660 4440 { lab=k30_S_bar}
N 580 4460 660 4460 { lab=x31_S}
N 580 4480 660 4480 { lab=x31_S_bar}
N 580 4500 660 4500 { lab=k31_S}
N 580 4520 660 4520 { lab=k31_S_bar}
N 580 4540 660 4540 { lab=Dis0_S}
N 580 4560 660 4560 { lab=Dis1_S}
N 580 4580 660 4580 { lab=Dis2_S}
N 580 4600 660 4600 { lab=Dis3_S}
N 580 4620 660 4620 { lab=CLK0_S}
N 580 4640 660 4640 { lab=CLK1_S}
N 580 4660 660 4660 { lab=CLK2_S}
N 580 4680 660 4680 { lab=CLK3_S}
N 960 4220 1180 4220 { lab=s28_norm}
N 960 4240 1180 4240 { lab=s28_norm_bar}
N 960 4260 1180 4260 { lab=s29_norm}
N 960 4280 1180 4280 { lab=s29_norm_bar}
N 960 4300 1180 4300 { lab=s30_norm}
N 960 4320 1180 4320 { lab=s30_norm_bar}
N 960 4340 1180 4340 { lab=s31_norm}
N 960 4360 1180 4360 { lab=s31_norm_bar}
N 1180 4220 1210 4220 { lab=s28_norm}
N 1180 4240 1210 4240 { lab=s28_norm_bar}
N 1180 4260 1210 4260 { lab=s29_norm}
N 1180 4280 1210 4280 { lab=s29_norm_bar}
N 1180 4300 1210 4300 { lab=s30_norm}
N 1180 4320 1210 4320 { lab=s30_norm_bar}
N 1180 4340 1210 4340 { lab=s31_norm}
N 1180 4360 1210 4360 { lab=s31_norm_bar}
N 980 4180 980 4220 { lab=s28_norm}
N 1010 4180 1010 4240 { lab=s28_norm_bar}
N 1040 4180 1040 4260 { lab=s29_norm}
N 1070 4180 1070 4280 { lab=s29_norm_bar}
N 1100 4180 1100 4300 { lab=s30_norm}
N 1130 4180 1130 4320 { lab=s30_norm_bar}
N 1160 4180 1160 4340 { lab=s31_norm}
N 1190 4180 1190 4360 { lab=s31_norm_bar}
N 1920 800 2000 800 { lab=x32_S}
N 1920 820 2000 820 { lab=x32_S_bar}
N 1920 840 2000 840 { lab=k32_S}
N 1920 860 2000 860 { lab=k32_S_bar}
N 1920 880 2000 880 { lab=x33_S}
N 1920 900 2000 900 { lab=x33_S_bar}
N 1920 920 2000 920 { lab=k33_S}
N 1920 940 2000 940 { lab=k33_S_bar}
N 1920 960 2000 960 { lab=x34_S}
N 1920 980 2000 980 { lab=x34_S_bar}
N 1920 1000 2000 1000 { lab=k34_S}
N 1920 1020 2000 1020 { lab=k34_S_bar}
N 1920 1040 2000 1040 { lab=x35_S}
N 1920 1060 2000 1060 { lab=x35_S_bar}
N 1920 1080 2000 1080 { lab=k35_S}
N 1920 1100 2000 1100 { lab=k35_S_bar}
N 1920 1120 2000 1120 { lab=Dis0_S}
N 1920 1140 2000 1140 { lab=Dis1_S}
N 1920 1160 2000 1160 { lab=Dis2_S}
N 1920 1180 2000 1180 { lab=Dis3_S}
N 1920 1200 2000 1200 { lab=CLK0_S}
N 1920 1220 2000 1220 { lab=CLK1_S}
N 1920 1240 2000 1240 { lab=CLK2_S}
N 1920 1260 2000 1260 { lab=CLK3_S}
N 2300 800 2520 800 { lab=s32_norm}
N 2300 820 2520 820 { lab=s32_norm_bar}
N 2300 840 2520 840 { lab=s33_norm}
N 2300 860 2520 860 { lab=s33_norm_bar}
N 2300 880 2520 880 { lab=s34_norm}
N 2300 900 2520 900 { lab=s34_norm_bar}
N 2300 920 2520 920 { lab=s35_norm}
N 2300 940 2520 940 { lab=s35_norm_bar}
N 2520 800 2550 800 { lab=s32_norm}
N 2520 820 2550 820 { lab=s32_norm_bar}
N 2520 840 2550 840 { lab=s33_norm}
N 2520 860 2550 860 { lab=s33_norm_bar}
N 2520 880 2550 880 { lab=s34_norm}
N 2520 900 2550 900 { lab=s34_norm_bar}
N 2520 920 2550 920 { lab=s35_norm}
N 2520 940 2550 940 { lab=s35_norm_bar}
N 2320 760 2320 800 { lab=s32_norm}
N 2350 760 2350 820 { lab=s32_norm_bar}
N 2380 760 2380 840 { lab=s33_norm}
N 2410 760 2410 860 { lab=s33_norm_bar}
N 2440 760 2440 880 { lab=s34_norm}
N 2470 760 2470 900 { lab=s34_norm_bar}
N 2500 760 2500 920 { lab=s35_norm}
N 2530 760 2530 940 { lab=s35_norm_bar}
N 1920 1350 2000 1350 { lab=x36_S}
N 1920 1370 2000 1370 { lab=x36_S_bar}
N 1920 1390 2000 1390 { lab=k36_S}
N 1920 1410 2000 1410 { lab=k36_S_bar}
N 1920 1430 2000 1430 { lab=x37_S}
N 1920 1450 2000 1450 { lab=x37_S_bar}
N 1920 1470 2000 1470 { lab=k37_S}
N 1920 1490 2000 1490 { lab=k37_S_bar}
N 1920 1510 2000 1510 { lab=x38_S}
N 1920 1530 2000 1530 { lab=x38_S_bar}
N 1920 1550 2000 1550 { lab=k38_S}
N 1920 1570 2000 1570 { lab=k38_S_bar}
N 1920 1590 2000 1590 { lab=x39_S}
N 1920 1610 2000 1610 { lab=x39_S_bar}
N 1920 1630 2000 1630 { lab=k39_S}
N 1920 1650 2000 1650 { lab=k39_S_bar}
N 1920 1670 2000 1670 { lab=Dis0_S}
N 1920 1690 2000 1690 { lab=Dis1_S}
N 1920 1710 2000 1710 { lab=Dis2_S}
N 1920 1730 2000 1730 { lab=Dis3_S}
N 1920 1750 2000 1750 { lab=CLK0_S}
N 1920 1770 2000 1770 { lab=CLK1_S}
N 1920 1790 2000 1790 { lab=CLK2_S}
N 1920 1810 2000 1810 { lab=CLK3_S}
N 2300 1350 2520 1350 { lab=s36_norm}
N 2300 1370 2520 1370 { lab=s36_norm_bar}
N 2300 1390 2520 1390 { lab=s37_norm}
N 2300 1410 2520 1410 { lab=s37_norm_bar}
N 2300 1430 2520 1430 { lab=s38_norm}
N 2300 1450 2520 1450 { lab=s38_norm_bar}
N 2300 1470 2520 1470 { lab=s39_norm}
N 2300 1490 2520 1490 { lab=s39_norm_bar}
N 2520 1350 2550 1350 { lab=s36_norm}
N 2520 1370 2550 1370 { lab=s36_norm_bar}
N 2520 1390 2550 1390 { lab=s37_norm}
N 2520 1410 2550 1410 { lab=s37_norm_bar}
N 2520 1430 2550 1430 { lab=s38_norm}
N 2520 1450 2550 1450 { lab=s38_norm_bar}
N 2520 1470 2550 1470 { lab=s39_norm}
N 2520 1490 2550 1490 { lab=s39_norm_bar}
N 2320 1310 2320 1350 { lab=s36_norm}
N 2350 1310 2350 1370 { lab=s36_norm_bar}
N 2380 1310 2380 1390 { lab=s37_norm}
N 2410 1310 2410 1410 { lab=s37_norm_bar}
N 2440 1310 2440 1430 { lab=s38_norm}
N 2470 1310 2470 1450 { lab=s38_norm_bar}
N 2500 1310 2500 1470 { lab=s39_norm}
N 2530 1310 2530 1490 { lab=s39_norm_bar}
N 1920 1900 2000 1900 { lab=x40_S}
N 1920 1920 2000 1920 { lab=x40_S_bar}
N 1920 1940 2000 1940 { lab=k40_S}
N 1920 1960 2000 1960 { lab=k40_S_bar}
N 1920 1980 2000 1980 { lab=x41_S}
N 1920 2000 2000 2000 { lab=x41_S_bar}
N 1920 2020 2000 2020 { lab=k41_S}
N 1920 2040 2000 2040 { lab=k41_S_bar}
N 1920 2060 2000 2060 { lab=x42_S}
N 1920 2080 2000 2080 { lab=x42_S_bar}
N 1920 2100 2000 2100 { lab=k42_S}
N 1920 2120 2000 2120 { lab=k42_S_bar}
N 1920 2140 2000 2140 { lab=x43_S}
N 1920 2160 2000 2160 { lab=x43_S_bar}
N 1920 2180 2000 2180 { lab=k43_S}
N 1920 2200 2000 2200 { lab=k43_S_bar}
N 1920 2220 2000 2220 { lab=Dis0_S}
N 1920 2240 2000 2240 { lab=Dis1_S}
N 1920 2260 2000 2260 { lab=Dis2_S}
N 1920 2280 2000 2280 { lab=Dis3_S}
N 1920 2300 2000 2300 { lab=CLK0_S}
N 1920 2320 2000 2320 { lab=CLK1_S}
N 1920 2340 2000 2340 { lab=CLK2_S}
N 1920 2360 2000 2360 { lab=CLK3_S}
N 2300 1900 2520 1900 { lab=s40_norm}
N 2300 1920 2520 1920 { lab=s40_norm_bar}
N 2300 1940 2520 1940 { lab=s41_norm}
N 2300 1960 2520 1960 { lab=s41_norm_bar}
N 2300 1980 2520 1980 { lab=s42_norm}
N 2300 2000 2520 2000 { lab=s42_norm_bar}
N 2300 2020 2520 2020 { lab=s43_norm}
N 2300 2040 2520 2040 { lab=s43_norm_bar}
N 2520 1900 2550 1900 { lab=s40_norm}
N 2520 1920 2550 1920 { lab=s40_norm_bar}
N 2520 1940 2550 1940 { lab=s41_norm}
N 2520 1960 2550 1960 { lab=s41_norm_bar}
N 2520 1980 2550 1980 { lab=s42_norm}
N 2520 2000 2550 2000 { lab=s42_norm_bar}
N 2520 2020 2550 2020 { lab=s43_norm}
N 2520 2040 2550 2040 { lab=s43_norm_bar}
N 2320 1860 2320 1900 { lab=s40_norm}
N 2350 1860 2350 1920 { lab=s40_norm_bar}
N 2380 1860 2380 1940 { lab=s41_norm}
N 2410 1860 2410 1960 { lab=s41_norm_bar}
N 2440 1860 2440 1980 { lab=s42_norm}
N 2470 1860 2470 2000 { lab=s42_norm_bar}
N 2500 1860 2500 2020 { lab=s43_norm}
N 2530 1860 2530 2040 { lab=s43_norm_bar}
N 1920 2450 2000 2450 { lab=x44_S}
N 1920 2470 2000 2470 { lab=x44_S_bar}
N 1920 2490 2000 2490 { lab=k44_S}
N 1920 2510 2000 2510 { lab=k44_S_bar}
N 1920 2530 2000 2530 { lab=x45_S}
N 1920 2550 2000 2550 { lab=x45_S_bar}
N 1920 2570 2000 2570 { lab=k45_S}
N 1920 2590 2000 2590 { lab=k45_S_bar}
N 1920 2610 2000 2610 { lab=x46_S}
N 1920 2630 2000 2630 { lab=x46_S_bar}
N 1920 2650 2000 2650 { lab=k46_S}
N 1920 2670 2000 2670 { lab=k46_S_bar}
N 1920 2690 2000 2690 { lab=x47_S}
N 1920 2710 2000 2710 { lab=x47_S_bar}
N 1920 2730 2000 2730 { lab=k47_S}
N 1920 2750 2000 2750 { lab=k47_S_bar}
N 1920 2770 2000 2770 { lab=Dis0_S}
N 1920 2790 2000 2790 { lab=Dis1_S}
N 1920 2810 2000 2810 { lab=Dis2_S}
N 1920 2830 2000 2830 { lab=Dis3_S}
N 1920 2850 2000 2850 { lab=CLK0_S}
N 1920 2870 2000 2870 { lab=CLK1_S}
N 1920 2890 2000 2890 { lab=CLK2_S}
N 1920 2910 2000 2910 { lab=CLK3_S}
N 2300 2450 2520 2450 { lab=s44_norm}
N 2300 2470 2520 2470 { lab=s44_norm_bar}
N 2300 2490 2520 2490 { lab=s45_norm}
N 2300 2510 2520 2510 { lab=s45_norm_bar}
N 2300 2530 2520 2530 { lab=s46_norm}
N 2300 2550 2520 2550 { lab=s46_norm_bar}
N 2300 2570 2520 2570 { lab=s47_norm}
N 2300 2590 2520 2590 { lab=s47_norm_bar}
N 2520 2450 2550 2450 { lab=s44_norm}
N 2520 2470 2550 2470 { lab=s44_norm_bar}
N 2520 2490 2550 2490 { lab=s45_norm}
N 2520 2510 2550 2510 { lab=s45_norm_bar}
N 2520 2530 2550 2530 { lab=s46_norm}
N 2520 2550 2550 2550 { lab=s46_norm_bar}
N 2520 2570 2550 2570 { lab=s47_norm}
N 2520 2590 2550 2590 { lab=s47_norm_bar}
N 2320 2410 2320 2450 { lab=s44_norm}
N 2350 2410 2350 2470 { lab=s44_norm_bar}
N 2380 2410 2380 2490 { lab=s45_norm}
N 2410 2410 2410 2510 { lab=s45_norm_bar}
N 2440 2410 2440 2530 { lab=s46_norm}
N 2470 2410 2470 2550 { lab=s46_norm_bar}
N 2500 2410 2500 2570 { lab=s47_norm}
N 2530 2410 2530 2590 { lab=s47_norm_bar}
N 1920 2970 2000 2970 { lab=x48_S}
N 1920 2990 2000 2990 { lab=x48_S_bar}
N 1920 3010 2000 3010 { lab=k48_S}
N 1920 3030 2000 3030 { lab=k48_S_bar}
N 1920 3050 2000 3050 { lab=x49_S}
N 1920 3070 2000 3070 { lab=x49_S_bar}
N 1920 3090 2000 3090 { lab=k49_S}
N 1920 3110 2000 3110 { lab=k49_S_bar}
N 1920 3130 2000 3130 { lab=x50_S}
N 1920 3150 2000 3150 { lab=x50_S_bar}
N 1920 3170 2000 3170 { lab=k50_S}
N 1920 3190 2000 3190 { lab=k50_S_bar}
N 1920 3210 2000 3210 { lab=x51_S}
N 1920 3230 2000 3230 { lab=x51_S_bar}
N 1920 3250 2000 3250 { lab=k51_S}
N 1920 3270 2000 3270 { lab=k51_S_bar}
N 1920 3290 2000 3290 { lab=Dis0_S}
N 1920 3310 2000 3310 { lab=Dis1_S}
N 1920 3330 2000 3330 { lab=Dis2_S}
N 1920 3350 2000 3350 { lab=Dis3_S}
N 1920 3370 2000 3370 { lab=CLK0_S}
N 1920 3390 2000 3390 { lab=CLK1_S}
N 1920 3410 2000 3410 { lab=CLK2_S}
N 1920 3430 2000 3430 { lab=CLK3_S}
N 2300 2970 2520 2970 { lab=s48_norm}
N 2300 2990 2520 2990 { lab=s48_norm_bar}
N 2300 3010 2520 3010 { lab=s49_norm}
N 2300 3030 2520 3030 { lab=s49_norm_bar}
N 2300 3050 2520 3050 { lab=s50_norm}
N 2300 3070 2520 3070 { lab=s50_norm_bar}
N 2300 3090 2520 3090 { lab=s51_norm}
N 2300 3110 2520 3110 { lab=s51_norm_bar}
N 2520 2970 2550 2970 { lab=s48_norm}
N 2520 2990 2550 2990 { lab=s48_norm_bar}
N 2520 3010 2550 3010 { lab=s49_norm}
N 2520 3030 2550 3030 { lab=s49_norm_bar}
N 2520 3050 2550 3050 { lab=s50_norm}
N 2520 3070 2550 3070 { lab=s50_norm_bar}
N 2520 3090 2550 3090 { lab=s51_norm}
N 2520 3110 2550 3110 { lab=s51_norm_bar}
N 2320 2930 2320 2970 { lab=s48_norm}
N 2350 2930 2350 2990 { lab=s48_norm_bar}
N 2380 2930 2380 3010 { lab=s49_norm}
N 2410 2930 2410 3030 { lab=s49_norm_bar}
N 2440 2930 2440 3050 { lab=s50_norm}
N 2470 2930 2470 3070 { lab=s50_norm_bar}
N 2500 2930 2500 3090 { lab=s51_norm}
N 2530 2930 2530 3110 { lab=s51_norm_bar}
N 1920 3520 2000 3520 { lab=x52_S}
N 1920 3540 2000 3540 { lab=x52_S_bar}
N 1920 3560 2000 3560 { lab=k52_S}
N 1920 3580 2000 3580 { lab=k52_S_bar}
N 1920 3600 2000 3600 { lab=x53_S}
N 1920 3620 2000 3620 { lab=x53_S_bar}
N 1920 3640 2000 3640 { lab=k53_S}
N 1920 3660 2000 3660 { lab=k53_S_bar}
N 1920 3680 2000 3680 { lab=x54_S}
N 1920 3700 2000 3700 { lab=x54_S_bar}
N 1920 3720 2000 3720 { lab=k54_S}
N 1920 3740 2000 3740 { lab=k54_S_bar}
N 1920 3760 2000 3760 { lab=x55_S}
N 1920 3780 2000 3780 { lab=x55_S_bar}
N 1920 3800 2000 3800 { lab=k55_S}
N 1920 3820 2000 3820 { lab=k55_S_bar}
N 1920 3840 2000 3840 { lab=Dis0_S}
N 1920 3860 2000 3860 { lab=Dis1_S}
N 1920 3880 2000 3880 { lab=Dis2_S}
N 1920 3900 2000 3900 { lab=Dis3_S}
N 1920 3920 2000 3920 { lab=CLK0_S}
N 1920 3940 2000 3940 { lab=CLK1_S}
N 1920 3960 2000 3960 { lab=CLK2_S}
N 1920 3980 2000 3980 { lab=CLK3_S}
N 2300 3520 2520 3520 { lab=s52_norm}
N 2300 3540 2520 3540 { lab=s52_norm_bar}
N 2300 3560 2520 3560 { lab=s53_norm}
N 2300 3580 2520 3580 { lab=s53_norm_bar}
N 2300 3600 2520 3600 { lab=s54_norm}
N 2300 3620 2520 3620 { lab=s54_norm_bar}
N 2300 3640 2520 3640 { lab=s55_norm}
N 2300 3660 2520 3660 { lab=s55_norm_bar}
N 2520 3520 2550 3520 { lab=s52_norm}
N 2520 3540 2550 3540 { lab=s52_norm_bar}
N 2520 3560 2550 3560 { lab=s53_norm}
N 2520 3580 2550 3580 { lab=s53_norm_bar}
N 2520 3600 2550 3600 { lab=s54_norm}
N 2520 3620 2550 3620 { lab=s54_norm_bar}
N 2520 3640 2550 3640 { lab=s55_norm}
N 2520 3660 2550 3660 { lab=s55_norm_bar}
N 2320 3480 2320 3520 { lab=s52_norm}
N 2350 3480 2350 3540 { lab=s52_norm_bar}
N 2380 3480 2380 3560 { lab=s53_norm}
N 2410 3480 2410 3580 { lab=s53_norm_bar}
N 2440 3480 2440 3600 { lab=s54_norm}
N 2470 3480 2470 3620 { lab=s54_norm_bar}
N 2500 3480 2500 3640 { lab=s55_norm}
N 2530 3480 2530 3660 { lab=s55_norm_bar}
N 1920 4070 2000 4070 { lab=x56_S}
N 1920 4090 2000 4090 { lab=x56_S_bar}
N 1920 4110 2000 4110 { lab=k56_S}
N 1920 4130 2000 4130 { lab=k56_S_bar}
N 1920 4150 2000 4150 { lab=x57_S}
N 1920 4170 2000 4170 { lab=x57_S_bar}
N 1920 4190 2000 4190 { lab=k57_S}
N 1920 4210 2000 4210 { lab=k57_S_bar}
N 1920 4230 2000 4230 { lab=x58_S}
N 1920 4250 2000 4250 { lab=x58_S_bar}
N 1920 4270 2000 4270 { lab=k58_S}
N 1920 4290 2000 4290 { lab=k58_S_bar}
N 1920 4310 2000 4310 { lab=x59_S}
N 1920 4330 2000 4330 { lab=x59_S_bar}
N 1920 4350 2000 4350 { lab=k59_S}
N 1920 4370 2000 4370 { lab=k59_S_bar}
N 1920 4390 2000 4390 { lab=Dis0_S}
N 1920 4410 2000 4410 { lab=Dis1_S}
N 1920 4430 2000 4430 { lab=Dis2_S}
N 1920 4450 2000 4450 { lab=Dis3_S}
N 1920 4470 2000 4470 { lab=CLK0_S}
N 1920 4490 2000 4490 { lab=CLK1_S}
N 1920 4510 2000 4510 { lab=CLK2_S}
N 1920 4530 2000 4530 { lab=CLK3_S}
N 2300 4070 2520 4070 { lab=s56_norm}
N 2300 4090 2520 4090 { lab=s56_norm_bar}
N 2300 4110 2520 4110 { lab=s57_norm}
N 2300 4130 2520 4130 { lab=s57_norm_bar}
N 2300 4150 2520 4150 { lab=s58_norm}
N 2300 4170 2520 4170 { lab=s58_norm_bar}
N 2300 4190 2520 4190 { lab=s59_norm}
N 2300 4210 2520 4210 { lab=s59_norm_bar}
N 2520 4070 2550 4070 { lab=s56_norm}
N 2520 4090 2550 4090 { lab=s56_norm_bar}
N 2520 4110 2550 4110 { lab=s57_norm}
N 2520 4130 2550 4130 { lab=s57_norm_bar}
N 2520 4150 2550 4150 { lab=s58_norm}
N 2520 4170 2550 4170 { lab=s58_norm_bar}
N 2520 4190 2550 4190 { lab=s59_norm}
N 2520 4210 2550 4210 { lab=s59_norm_bar}
N 2320 4030 2320 4070 { lab=s56_norm}
N 2350 4030 2350 4090 { lab=s56_norm_bar}
N 2380 4030 2380 4110 { lab=s57_norm}
N 2410 4030 2410 4130 { lab=s57_norm_bar}
N 2440 4030 2440 4150 { lab=s58_norm}
N 2470 4030 2470 4170 { lab=s58_norm_bar}
N 2500 4030 2500 4190 { lab=s59_norm}
N 2530 4030 2530 4210 { lab=s59_norm_bar}
N 1920 4620 2000 4620 { lab=x60_S}
N 1920 4640 2000 4640 { lab=x60_S_bar}
N 1920 4660 2000 4660 { lab=k60_S}
N 1920 4680 2000 4680 { lab=k60_S_bar}
N 1920 4700 2000 4700 { lab=x61_S}
N 1920 4720 2000 4720 { lab=x61_S_bar}
N 1920 4740 2000 4740 { lab=k61_S}
N 1920 4760 2000 4760 { lab=k61_S_bar}
N 1920 4780 2000 4780 { lab=x62_S}
N 1920 4800 2000 4800 { lab=x62_S_bar}
N 1920 4820 2000 4820 { lab=k62_S}
N 1920 4840 2000 4840 { lab=k62_S_bar}
N 1920 4860 2000 4860 { lab=x63_S}
N 1920 4880 2000 4880 { lab=x63_S_bar}
N 1920 4900 2000 4900 { lab=k63_S}
N 1920 4920 2000 4920 { lab=k63_S_bar}
N 1920 4940 2000 4940 { lab=Dis0_S}
N 1920 4960 2000 4960 { lab=Dis1_S}
N 1920 4980 2000 4980 { lab=Dis2_S}
N 1920 5000 2000 5000 { lab=Dis3_S}
N 1920 5020 2000 5020 { lab=CLK0_S}
N 1920 5040 2000 5040 { lab=CLK1_S}
N 1920 5060 2000 5060 { lab=CLK2_S}
N 1920 5080 2000 5080 { lab=CLK3_S}
N 2300 4620 2520 4620 { lab=s60_norm}
N 2300 4640 2520 4640 { lab=s60_norm_bar}
N 2300 4660 2520 4660 { lab=s61_norm}
N 2300 4680 2520 4680 { lab=s61_norm_bar}
N 2300 4700 2520 4700 { lab=s62_norm}
N 2300 4720 2520 4720 { lab=s62_norm_bar}
N 2300 4740 2520 4740 { lab=s63_norm}
N 2300 4760 2520 4760 { lab=s63_norm_bar}
N 2520 4620 2550 4620 { lab=s60_norm}
N 2520 4640 2550 4640 { lab=s60_norm_bar}
N 2520 4660 2550 4660 { lab=s61_norm}
N 2520 4680 2550 4680 { lab=s61_norm_bar}
N 2520 4700 2550 4700 { lab=s62_norm}
N 2520 4720 2550 4720 { lab=s62_norm_bar}
N 2520 4740 2550 4740 { lab=s63_norm}
N 2520 4760 2550 4760 { lab=s63_norm_bar}
N 2320 4580 2320 4620 { lab=s60_norm}
N 2350 4580 2350 4640 { lab=s60_norm_bar}
N 2380 4580 2380 4660 { lab=s61_norm}
N 2410 4580 2410 4680 { lab=s61_norm_bar}
N 2440 4580 2440 4700 { lab=s62_norm}
N 2470 4580 2470 4720 { lab=s62_norm_bar}
N 2500 4580 2500 4740 { lab=s63_norm}
N 2530 4580 2530 4760 { lab=s63_norm_bar}
N 640 800 860 800 { lab=s4_norm}
N 640 820 860 820 { lab=s4_norm_bar}
N 640 840 860 840 { lab=s5_norm}
N 640 860 860 860 { lab=s5_norm_bar}
N 640 880 860 880 { lab=s6_norm}
N 640 900 860 900 { lab=s6_norm_bar}
N 640 920 860 920 { lab=s7_norm}
N 640 940 860 940 { lab=s7_norm_bar}
N 860 800 890 800 { lab=s4_norm}
N 860 820 890 820 { lab=s4_norm_bar}
N 860 840 890 840 { lab=s5_norm}
N 860 860 890 860 { lab=s5_norm_bar}
N 860 880 890 880 { lab=s6_norm}
N 860 900 890 900 { lab=s6_norm_bar}
N 860 920 890 920 { lab=s7_norm}
N 860 940 890 940 { lab=s7_norm_bar}
N 660 760 660 800 { lab=s4_norm}
N 690 760 690 820 { lab=s4_norm_bar}
N 720 760 720 840 { lab=s5_norm}
N 750 760 750 860 { lab=s5_norm_bar}
N 780 760 780 880 { lab=s6_norm}
N 810 760 810 900 { lab=s6_norm_bar}
N 840 760 840 920 { lab=s7_norm}
N 870 760 870 940 { lab=s7_norm_bar}
N 3840 5090 3890 5090 { lab=k63_bar_S}
N 3840 5070 3890 5070 { lab=k63_S}
N 3840 5050 3890 5050 { lab=x63_bar_S}
N 3840 5030 3890 5030 { lab=x63_S}
N 3840 5010 3890 5010 { lab=k62_bar_S}
N 3840 4990 3890 4990 { lab=k62_S}
N 3840 4970 3890 4970 { lab=x62_bar_S}
N 3840 4950 3890 4950 { lab=x62_S}
N 3840 4930 3890 4930 { lab=k61_bar_S}
N 3840 4910 3890 4910 { lab=k61_S}
N 3840 4890 3890 4890 { lab=x61_bar_S}
N 3840 4870 3890 4870 { lab=x61_S}
N 3840 4850 3890 4850 { lab=k60_bar_S}
N 3840 4830 3890 4830 { lab=k60_S}
N 3840 4810 3890 4810 { lab=x60_bar_S}
N 3840 4790 3890 4790 { lab=x60_S}
N 3840 4770 3890 4770 { lab=k59_bar_S}
N 3840 4750 3890 4750 { lab=k59_S}
N 3840 4730 3890 4730 { lab=x59_bar_S}
N 3840 4710 3890 4710 { lab=x59_S}
N 3840 4690 3890 4690 { lab=k58_bar_S}
N 3840 4670 3890 4670 { lab=k58_S}
N 3840 4650 3890 4650 { lab=x58_bar_S}
N 3840 4630 3890 4630 { lab=x58_S}
N 3840 4610 3890 4610 { lab=k57_bar_S}
N 3840 4590 3890 4590 { lab=k57_S}
N 3840 4570 3890 4570 { lab=x57_bar_S}
N 3840 4550 3890 4550 { lab=x57_S}
N 3840 4530 3890 4530 { lab=k56_bar_S}
N 3840 4510 3890 4510 { lab=k56_S}
N 3840 4490 3890 4490 { lab=x56_bar_S}
N 3840 4470 3890 4470 { lab=x56_S}
N 3840 4450 3890 4450 { lab=k55_bar_S}
N 3840 4430 3890 4430 { lab=k55_S}
N 3840 4410 3890 4410 { lab=x55_bar_S}
N 3840 4390 3890 4390 { lab=x55_S}
N 3840 4370 3890 4370 { lab=k54_bar_S}
N 3840 4350 3890 4350 { lab=k54_S}
N 3840 4330 3890 4330 { lab=x54_bar_S}
N 3840 4310 3890 4310 { lab=x54_S}
N 3840 4290 3890 4290 { lab=k53_bar_S}
N 3840 4270 3890 4270 { lab=k53_S}
N 3840 4250 3890 4250 { lab=x53_bar_S}
N 3840 4230 3890 4230 { lab=x53_S}
N 3840 4210 3890 4210 { lab=k52_bar_S}
N 3840 4190 3890 4190 { lab=k52_S}
N 3840 4170 3890 4170 { lab=x52_bar_S}
N 3840 4150 3890 4150 { lab=x52_S}
N 3840 4130 3890 4130 { lab=k51_bar_S}
N 3840 4110 3890 4110 { lab=k51_S}
N 3840 4090 3890 4090 { lab=x51_bar_S}
N 3840 4070 3890 4070 { lab=x51_S}
N 3840 4050 3890 4050 { lab=k50_bar_S}
N 3840 4030 3890 4030 { lab=k50_S}
N 3840 4010 3890 4010 { lab=x50_bar_S}
N 3840 3990 3890 3990 { lab=x50_S}
N 3840 3970 3890 3970 { lab=k49_bar_S}
N 3840 3950 3890 3950 { lab=k49_S}
N 3840 3930 3890 3930 { lab=x49_bar_S}
N 3840 3910 3890 3910 { lab=x49_S}
N 3840 3890 3890 3890 { lab=k48_bar_S}
N 3840 3870 3890 3870 { lab=k48_S}
N 3840 3850 3890 3850 { lab=x48_bar_S}
N 3840 3830 3890 3830 { lab=x48_S}
N 3840 3810 3890 3810 { lab=k47_bar_S}
N 3840 3790 3890 3790 { lab=k47_S}
N 3840 3770 3890 3770 { lab=x47_bar_S}
N 3840 3750 3890 3750 { lab=x47_S}
N 3840 3730 3890 3730 { lab=k46_bar_S}
N 3840 3710 3890 3710 { lab=k46_S}
N 3840 3690 3890 3690 { lab=x46_bar_S}
N 3840 3670 3890 3670 { lab=x46_S}
N 3840 3650 3890 3650 { lab=k45_bar_S}
N 3840 3630 3890 3630 { lab=k45_S}
N 3840 3610 3890 3610 { lab=x45_bar_S}
N 3840 3590 3890 3590 { lab=x45_S}
N 3840 3570 3890 3570 { lab=k44_bar_S}
N 3840 3550 3890 3550 { lab=k44_S}
N 3840 3530 3890 3530 { lab=x44_bar_S}
N 3840 3510 3890 3510 { lab=x44_S}
N 3840 3490 3890 3490 { lab=k43_bar_S}
N 3840 3470 3890 3470 { lab=k43_S}
N 3840 3450 3890 3450 { lab=x43_bar_S}
N 3840 3430 3890 3430 { lab=x43_S}
N 3840 3410 3890 3410 { lab=k42_bar_S}
N 3840 3390 3890 3390 { lab=k42_S}
N 3840 3370 3890 3370 { lab=x42_bar_S}
N 3840 3350 3890 3350 { lab=x42_S}
N 3840 3330 3890 3330 { lab=k41_bar_S}
N 3840 3310 3890 3310 { lab=k41_S}
N 3840 3290 3890 3290 { lab=x41_bar_S}
N 3840 3270 3890 3270 { lab=x41_S}
N 3840 3250 3890 3250 { lab=k40_bar_S}
N 3840 3230 3890 3230 { lab=k40_S}
N 3840 3210 3890 3210 { lab=x40_bar_S}
N 3840 3190 3890 3190 { lab=x40_S}
N 3840 3170 3890 3170 { lab=k39_bar_S}
N 3840 3150 3890 3150 { lab=k39_S}
N 3840 3130 3890 3130 { lab=x39_bar_S}
N 3840 3110 3890 3110 { lab=x39_S}
N 3840 3090 3890 3090 { lab=k38_bar_S}
N 3840 3070 3890 3070 { lab=k38_S}
N 3840 3050 3890 3050 { lab=x38_bar_S}
N 3840 3030 3890 3030 { lab=x38_S}
N 3840 3010 3890 3010 { lab=k37_bar_S}
N 3840 2990 3890 2990 { lab=k37_S}
N 3840 2970 3890 2970 { lab=x37_bar_S}
N 3840 2950 3890 2950 { lab=x37_S}
N 3840 2930 3890 2930 { lab=k36_bar_S}
N 3840 2910 3890 2910 { lab=k36_S}
N 3840 2890 3890 2890 { lab=x36_bar_S}
N 3840 2870 3890 2870 { lab=x36_S}
N 3840 2850 3890 2850 { lab=k35_bar_S}
N 3840 2830 3890 2830 { lab=k35_S}
N 3840 2810 3890 2810 { lab=x35_bar_S}
N 3840 2790 3890 2790 { lab=x35_S}
N 3840 2770 3890 2770 { lab=k34_bar_S}
N 3840 2750 3890 2750 { lab=k34_S}
N 3840 2730 3890 2730 { lab=x34_bar_S}
N 3840 2710 3890 2710 { lab=x34_S}
N 3840 2690 3890 2690 { lab=k33_bar_S}
N 3840 2670 3890 2670 { lab=k33_S}
N 3840 2650 3890 2650 { lab=x33_bar_S}
N 3840 2630 3890 2630 { lab=x33_S}
N 3840 2610 3890 2610 { lab=k32_bar_S}
N 3840 2590 3890 2590 { lab=k32_S}
N 3840 2570 3890 2570 { lab=x32_bar_S}
N 3840 2550 3890 2550 { lab=x32_S}
N 3840 2530 3890 2530 { lab=k31_bar_S}
N 3840 2510 3890 2510 { lab=k31_S}
N 3840 2490 3890 2490 { lab=x31_bar_S}
N 3840 2470 3890 2470 { lab=x31_S}
N 3840 2450 3890 2450 { lab=k30_bar_S}
N 3840 2430 3890 2430 { lab=k30_S}
N 3840 2410 3890 2410 { lab=x30_bar_S}
N 3840 2390 3890 2390 { lab=x30_S}
N 3840 2370 3890 2370 { lab=k29_bar_S}
N 3840 2350 3890 2350 { lab=k29_S}
N 3840 2330 3890 2330 { lab=x29_bar_S}
N 3840 2310 3890 2310 { lab=x29_S}
N 3840 2290 3890 2290 { lab=k28_bar_S}
N 3840 2270 3890 2270 { lab=k28_S}
N 3840 2250 3890 2250 { lab=x28_bar_S}
N 3840 2230 3890 2230 { lab=x28_S}
N 3840 2210 3890 2210 { lab=k27_bar_S}
N 3840 2190 3890 2190 { lab=k27_S}
N 3840 2170 3890 2170 { lab=x27_bar_S}
N 3840 2150 3890 2150 { lab=x27_S}
N 3840 2130 3890 2130 { lab=k26_bar_S}
N 3840 2110 3890 2110 { lab=k26_S}
N 3840 2090 3890 2090 { lab=x26_bar_S}
N 3840 2070 3890 2070 { lab=x26_S}
N 3840 2050 3890 2050 { lab=k25_bar_S}
N 3840 2030 3890 2030 { lab=k25_S}
N 3840 2010 3890 2010 { lab=x25_bar_S}
N 3840 1990 3890 1990 { lab=x25_S}
N 3840 1970 3890 1970 { lab=k24_bar_S}
N 3840 1950 3890 1950 { lab=k24_S}
N 3840 1930 3890 1930 { lab=x24_bar_S}
N 3840 1910 3890 1910 { lab=x24_S}
N 3840 1890 3890 1890 { lab=k23_bar_S}
N 3840 1870 3890 1870 { lab=k23_S}
N 3840 1850 3890 1850 { lab=x23_bar_S}
N 3840 1830 3890 1830 { lab=x23_S}
N 3840 1810 3890 1810 { lab=k22_bar_S}
N 3840 1790 3890 1790 { lab=k22_S}
N 3840 1770 3890 1770 { lab=x22_bar_S}
N 3840 1750 3890 1750 { lab=x22_S}
N 3840 1730 3890 1730 { lab=k21_bar_S}
N 3840 1710 3890 1710 { lab=k21_S}
N 3840 1690 3890 1690 { lab=x21_bar_S}
N 3840 1670 3890 1670 { lab=x21_S}
N 3840 1650 3890 1650 { lab=k20_bar_S}
N 3840 1630 3890 1630 { lab=k20_S}
N 3840 1610 3890 1610 { lab=x20_bar_S}
N 3840 1590 3890 1590 { lab=x20_S}
N 3840 1570 3890 1570 { lab=k19_bar_S}
N 3840 1550 3890 1550 { lab=k19_S}
N 3840 1530 3890 1530 { lab=x19_bar_S}
N 3840 1510 3890 1510 { lab=x19_S}
N 3840 1490 3890 1490 { lab=k18_bar_S}
N 3840 1470 3890 1470 { lab=k18_S}
N 3840 1450 3890 1450 { lab=x18_bar_S}
N 3840 1430 3890 1430 { lab=x18_S}
N 3840 1410 3890 1410 { lab=k17_bar_S}
N 3840 1390 3890 1390 { lab=k17_S}
N 3840 1370 3890 1370 { lab=x17_bar_S}
N 3840 1350 3890 1350 { lab=x17_S}
N 3840 1330 3890 1330 { lab=k16_bar_S}
N 3840 1310 3890 1310 { lab=k16_S}
N 3840 1290 3890 1290 { lab=x16_bar_S}
N 3840 1270 3890 1270 { lab=x16_S}
N 3840 1250 3890 1250 { lab=k15_bar_S}
N 3840 1230 3890 1230 { lab=k15_S}
N 3840 1210 3890 1210 { lab=x15_bar_S}
N 3840 1190 3890 1190 { lab=x15_S}
N 3840 1170 3890 1170 { lab=k14_bar_S}
N 3840 1150 3890 1150 { lab=k14_S}
N 3840 1130 3890 1130 { lab=x14_bar_S}
N 3840 1110 3890 1110 { lab=x14_S}
N 3840 1090 3890 1090 { lab=k13_bar_S}
N 3840 1070 3890 1070 { lab=k13_S}
N 3840 1050 3890 1050 { lab=x13_bar_S}
N 3840 1030 3890 1030 { lab=x13_S}
N 3840 1010 3890 1010 { lab=k12_bar_S}
N 3840 990 3890 990 { lab=k12_S}
N 3840 970 3890 970 { lab=x12_bar_S}
N 3840 950 3890 950 { lab=x12_S}
N 3840 930 3890 930 { lab=k11_bar_S}
N 3840 910 3890 910 { lab=k11_S}
N 3840 890 3890 890 { lab=x11_bar_S}
N 3840 870 3890 870 { lab=x11_S}
N 3840 850 3890 850 { lab=k10_bar_S}
N 3840 830 3890 830 { lab=k10_S}
N 3840 810 3890 810 { lab=x10_bar_S}
N 3840 790 3890 790 { lab=x10_S}
N 3840 770 3890 770 { lab=k9_bar_S}
N 3840 750 3890 750 { lab=k9_S}
N 3840 730 3890 730 { lab=x9_bar_S}
N 3840 710 3890 710 { lab=x9_S}
N 3840 690 3890 690 { lab=k8_bar_S}
N 3840 670 3890 670 { lab=k8_S}
N 3840 650 3890 650 { lab=x8_bar_S}
N 3840 630 3890 630 { lab=x8_S}
N 3840 610 3890 610 { lab=k7_bar_S}
N 3840 590 3890 590 { lab=k7_S}
N 3840 570 3890 570 { lab=x7_bar_S}
N 3840 550 3890 550 { lab=x7_S}
N 3840 530 3890 530 { lab=k6_bar_S}
N 3840 510 3890 510 { lab=k6_S}
N 3840 490 3890 490 { lab=x6_bar_S}
N 3840 470 3890 470 { lab=x6_S}
N 3840 450 3890 450 { lab=k5_bar_S}
N 3840 430 3890 430 { lab=k5_S}
N 3840 410 3890 410 { lab=x5_bar_S}
N 3840 390 3890 390 { lab=x5_S}
N 3840 370 3890 370 { lab=k4_bar_S}
N 3840 350 3890 350 { lab=k4_S}
N 3840 330 3890 330 { lab=x4_bar_S}
N 3840 310 3890 310 { lab=x4_S}
N 3840 290 3890 290 { lab=k3_bar_S}
N 3840 270 3890 270 { lab=k3_S}
N 3840 250 3890 250 { lab=x3_bar_S}
N 3840 230 3890 230 { lab=x3_S}
N 3840 210 3890 210 { lab=k2_bar_S}
N 3840 190 3890 190 { lab=k2_S}
N 3840 170 3890 170 { lab=x2_bar_S}
N 3840 150 3890 150 { lab=x2_S}
N 3840 130 3890 130 { lab=k1_bar_S}
N 3840 110 3890 110 { lab=k1_S}
N 3840 90 3890 90 { lab=x1_bar_S}
N 3840 70 3890 70 { lab=x1_S}
N 3840 50 3890 50 { lab=k0_bar_S}
N 3840 30 3890 30 { lab=k0_S}
N 3840 10 3890 10 { lab=x0_bar_S}
N 3840 -10 3890 -10 { lab=x0_S}
C {devices/lab_pin.sym} 1160 -290 2 0 {name=l42 sig_type=std_logic lab=AND2}
C {devices/lab_pin.sym} 1160 -70 2 0 {name=l67 sig_type=std_logic lab=AND3}
C {devices/lab_pin.sym} 1160 -270 2 0 {name=l68 sig_type=std_logic lab=NAND2}
C {devices/lab_pin.sym} 1160 -50 2 0 {name=l69 sig_type=std_logic lab=NAND3}
C {devices/lab_pin.sym} 650 -320 2 0 {name=l1 sig_type=std_logic lab=XNOR1}
C {devices/lab_pin.sym} 650 -30 2 0 {name=l2 sig_type=std_logic lab=AND1}
C {devices/lab_pin.sym} 650 -170 2 0 {name=l3 sig_type=std_logic lab=NOR1}
C {devices/lab_pin.sym} 650 -190 2 0 {name=l40 sig_type=std_logic lab=OR1}
C {devices/lab_pin.sym} 650 -340 2 0 {name=l61 sig_type=std_logic lab=XOR1}
C {devices/lab_pin.sym} 650 -10 2 0 {name=l52 sig_type=std_logic lab=NAND1}
C {EESPFAL_XOR_v3.sym} 480 -290 0 0 {name=x7}
C {EESPFAL_NOR_v3.sym} 480 -140 0 0 {name=x2}
C {EESPFAL_NOR_v3.sym} 1470 -150 0 0 {name=x3}
C {EESPFAL_NAND_v3.sym} 480 20 0 0 {name=x4}
C {EESPFAL_NAND_v3.sym} 980 -20 0 0 {name=x5}
C {EESPFAL_NAND_v3.sym} 980 -240 0 0 {name=x6}
C {devices/lab_pin.sym} 310 -110 2 1 {name=l50 sig_type=std_logic lab=Dis1}
C {devices/lab_pin.sym} 310 -90 2 1 {name=l51 sig_type=std_logic lab=CLK1}
C {devices/lab_pin.sym} 310 50 2 1 {name=l75 sig_type=std_logic lab=Dis1}
C {devices/lab_pin.sym} 310 70 2 1 {name=l76 sig_type=std_logic lab=CLK1}
C {devices/lab_pin.sym} 800 30 0 0 {name=l77 sig_type=std_logic lab=CLK2}
C {devices/lab_pin.sym} 800 10 0 0 {name=l78 sig_type=std_logic lab=Dis2}
C {devices/gnd.sym} 1660 -140 0 0 {name=l79 lab=GND}
C {devices/lab_pin.sym} 1650 -200 0 1 {name=l55 sig_type=std_logic lab=s0}
C {devices/lab_pin.sym} 1650 -180 0 1 {name=l56 sig_type=std_logic lab=s0_bar}
C {devices/gnd.sym} 1160 -30 0 0 {name=l62 lab=GND}
C {devices/gnd.sym} 1160 -250 0 0 {name=l63 lab=GND}
C {devices/gnd.sym} 660 -150 0 0 {name=l64 lab=GND}
C {devices/gnd.sym} 660 10 0 0 {name=l65 lab=GND}
C {devices/gnd.sym} 660 -300 0 0 {name=l66 lab=GND}
C {EESPFAL_4in_Buffer.sym} -150 -250 0 0 {name=x1}
C {devices/lab_pin.sym} -320 -340 0 0 {name=l70 sig_type=std_logic lab=x0}
C {devices/lab_pin.sym} -320 -320 0 0 {name=l71 sig_type=std_logic lab=x0_bar}
C {devices/lab_pin.sym} -320 -300 0 0 {name=l72 sig_type=std_logic lab=x1}
C {devices/lab_pin.sym} -320 -280 0 0 {name=l73 sig_type=std_logic lab=x1_bar}
C {devices/lab_pin.sym} -320 -260 0 0 {name=l74 sig_type=std_logic lab=x2}
C {devices/lab_pin.sym} -320 -240 0 0 {name=l80 sig_type=std_logic lab=x2_bar}
C {devices/lab_pin.sym} -320 -220 0 0 {name=l81 sig_type=std_logic lab=x3}
C {devices/lab_pin.sym} -320 -200 0 0 {name=l82 sig_type=std_logic lab=x3_bar}
C {devices/lab_pin.sym} -320 -180 0 0 {name=l83 sig_type=std_logic lab=CLK0}
C {devices/lab_pin.sym} -320 -160 0 0 {name=l84 sig_type=std_logic lab=Dis0}
C {devices/gnd.sym} 0 -180 0 0 {name=l85 lab=GND}
C {devices/lab_pin.sym} 30 -320 2 0 {name=l86 sig_type=std_logic lab=x0_buff}
C {devices/lab_pin.sym} 30 -340 2 0 {name=l87 sig_type=std_logic lab=x0_bar_buff}
C {devices/lab_pin.sym} 30 -280 2 0 {name=l88 sig_type=std_logic lab=x1_buff}
C {devices/lab_pin.sym} 30 -300 2 0 {name=l89 sig_type=std_logic lab=x1_bar_buff}
C {devices/lab_pin.sym} 30 -240 2 0 {name=l90 sig_type=std_logic lab=x2_buff}
C {devices/lab_pin.sym} 30 -260 2 0 {name=l91 sig_type=std_logic lab=x2_bar_buff}
C {devices/lab_pin.sym} 30 -200 2 0 {name=l92 sig_type=std_logic lab=x3_buff}
C {devices/lab_pin.sym} 30 -220 2 0 {name=l93 sig_type=std_logic lab=x3_bar_buff}
C {devices/lab_pin.sym} 310 -340 2 1 {name=l94 sig_type=std_logic lab=x0_buff}
C {devices/lab_pin.sym} 310 -320 2 1 {name=l95 sig_type=std_logic lab=x0_bar_buff}
C {devices/lab_pin.sym} 310 -300 2 1 {name=l36 sig_type=std_logic lab=x3_buff}
C {devices/lab_pin.sym} 310 -280 2 1 {name=l38 sig_type=std_logic lab=x3_bar_buff}
C {devices/lab_pin.sym} 310 -260 2 1 {name=l43 sig_type=std_logic lab=Dis1}
C {devices/lab_pin.sym} 310 -240 2 1 {name=l44 sig_type=std_logic lab=CLK1}
C {devices/lab_pin.sym} 800 -190 0 0 {name=l96 sig_type=std_logic lab=CLK2}
C {devices/lab_pin.sym} 800 -210 0 0 {name=l97 sig_type=std_logic lab=Dis2}
C {devices/lab_pin.sym} 1290 -100 0 0 {name=l98 sig_type=std_logic lab=CLK3}
C {devices/lab_pin.sym} 1290 -120 0 0 {name=l99 sig_type=std_logic lab=Dis3}
C {devices/lab_pin.sym} 310 -190 2 1 {name=l37 sig_type=std_logic lab=x1_buff}
C {devices/lab_pin.sym} 310 -170 2 1 {name=l39 sig_type=std_logic lab=x1_bar_buff}
C {devices/lab_pin.sym} 310 -150 2 1 {name=l41 sig_type=std_logic lab=x2_bar_buff}
C {devices/lab_pin.sym} 310 -130 2 1 {name=l45 sig_type=std_logic lab=x2_buff}
C {devices/lab_pin.sym} 310 -30 2 1 {name=l46 sig_type=std_logic lab=x2_buff}
C {devices/lab_pin.sym} 310 -10 2 1 {name=l47 sig_type=std_logic lab=x2_bar_buff}
C {devices/lab_pin.sym} 310 10 2 1 {name=l48 sig_type=std_logic lab=x1_bar_buff}
C {devices/lab_pin.sym} 310 30 2 1 {name=l49 sig_type=std_logic lab=x1_buff}
C {devices/lab_pin.sym} 1180 230 2 0 {name=l4 sig_type=std_logic lab=AND2}
C {devices/lab_pin.sym} 1180 450 2 0 {name=l5 sig_type=std_logic lab=AND3}
C {devices/lab_pin.sym} 1180 250 2 0 {name=l6 sig_type=std_logic lab=NAND2}
C {devices/lab_pin.sym} 1180 470 2 0 {name=l7 sig_type=std_logic lab=NAND3}
C {devices/lab_pin.sym} 670 200 2 0 {name=l8 sig_type=std_logic lab=XNOR1}
C {devices/lab_pin.sym} 670 490 2 0 {name=l9 sig_type=std_logic lab=AND1}
C {devices/lab_pin.sym} 670 350 2 0 {name=l10 sig_type=std_logic lab=NOR1}
C {devices/lab_pin.sym} 670 330 2 0 {name=l11 sig_type=std_logic lab=OR1}
C {devices/lab_pin.sym} 670 180 2 0 {name=l12 sig_type=std_logic lab=XOR1}
C {devices/lab_pin.sym} 670 510 2 0 {name=l13 sig_type=std_logic lab=NAND1}
C {EESPFAL_XOR_v3.sym} 500 230 0 0 {name=x8}
C {EESPFAL_NOR_v3.sym} 500 380 0 0 {name=x9}
C {EESPFAL_NOR_v3.sym} 1490 370 0 0 {name=x10}
C {EESPFAL_NAND_v3.sym} 500 540 0 0 {name=x11}
C {EESPFAL_NAND_v3.sym} 1000 500 0 0 {name=x12}
C {EESPFAL_NAND_v3.sym} 1000 280 0 0 {name=x13}
C {devices/lab_pin.sym} 820 530 2 1 {name=l14 sig_type=std_logic lab=Dis1}
C {devices/lab_pin.sym} 820 550 2 1 {name=l15 sig_type=std_logic lab=CLK1}
C {devices/gnd.sym} 1180 490 0 0 {name=l16 lab=GND}
C {devices/gnd.sym} 1180 270 0 0 {name=l17 lab=GND}
C {devices/gnd.sym} 680 370 0 0 {name=l18 lab=GND}
C {devices/gnd.sym} 680 530 0 0 {name=l19 lab=GND}
C {devices/gnd.sym} 680 220 0 0 {name=l20 lab=GND}
C {devices/iopin.sym} 1660 360 0 0 {name=p17 lab=GND}
C {devices/ipin.sym} 330 180 0 0 {name=p1 lab=x0}
C {devices/ipin.sym} 330 200 0 0 {name=p2 lab=x0_bar}
C {devices/ipin.sym} 330 330 0 0 {name=p7 lab=x1}
C {devices/ipin.sym} 330 350 0 0 {name=p8 lab=x1_bar}
C {devices/ipin.sym} 330 390 0 0 {name=p10 lab=x2}
C {devices/ipin.sym} 330 370 0 0 {name=p9 lab=x2_bar}
C {devices/ipin.sym} 330 220 0 0 {name=p3 lab=x3}
C {devices/ipin.sym} 330 240 0 0 {name=p4 lab=x3_bar}
C {devices/ipin.sym} 330 280 0 0 {name=p6 lab=CLK0}
C {devices/ipin.sym} 330 260 0 0 {name=p5 lab=Dis0}
C {devices/ipin.sym} 820 330 0 0 {name=p14 lab=CLK1}
C {devices/ipin.sym} 1310 400 0 0 {name=p11 lab=Dis2}
C {devices/ipin.sym} 1310 420 0 0 {name=p12 lab=CLK2}
C {devices/ipin.sym} 820 310 0 0 {name=p13 lab=Dis1}
C {devices/opin.sym} 1670 320 0 0 {name=p15 lab=s0}
C {devices/opin.sym} 1670 340 0 0 {name=p16 lab=s0_bar}
C {devices/lab_pin.sym} 210 180 0 0 {name=l21 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} 210 200 0 0 {name=l22 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} 750 310 0 0 {name=l23 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 750 330 0 0 {name=l24 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1220 400 0 0 {name=l57 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 1220 420 0 0 {name=l58 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 210 220 0 0 {name=l25 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} 210 240 0 0 {name=l26 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} 210 260 0 0 {name=l27 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 210 280 2 1 {name=l28 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 210 350 0 0 {name=l29 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} 210 330 0 0 {name=l30 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} 210 370 0 0 {name=l53 sig_type=std_logic lab=x2_bar_S}
C {devices/lab_pin.sym} 210 390 0 0 {name=l54 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} 330 410 0 0 {name=l31 sig_type=std_logic lab=Dis0}
C {devices/lab_pin.sym} 330 430 2 1 {name=l32 sig_type=std_logic lab=CLK0}
C {devices/lab_pin.sym} 330 570 0 0 {name=l59 sig_type=std_logic lab=Dis0}
C {devices/lab_pin.sym} 330 590 2 1 {name=l60 sig_type=std_logic lab=CLK0}
C {devices/lab_pin.sym} 330 490 0 0 {name=l33 sig_type=std_logic lab=x2}
C {devices/lab_pin.sym} 330 510 0 0 {name=l34 sig_type=std_logic lab=x2_bar}
C {devices/lab_pin.sym} 330 530 0 0 {name=l35 sig_type=std_logic lab=x1_bar}
C {devices/lab_pin.sym} 330 550 0 0 {name=l100 sig_type=std_logic lab=x1}
C {devices/gnd.sym} 1680 380 0 0 {name=l101 lab=GND}
C {devices/gnd.sym} -580 480 0 0 {name=l102 lab=GND}
C {devices/lab_pin.sym} -550 410 1 0 {name=l103 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} -520 440 1 0 {name=l104 sig_type=std_logic lab=x3_bar_S}
C {devices/gnd.sym} -490 570 0 0 {name=l105 lab=GND}
C {devices/gnd.sym} -520 540 0 0 {name=l106 lab=GND}
C {devices/lab_pin.sym} -490 470 1 0 {name=l107 sig_type=std_logic lab=x3_S}
C {devices/vsource.sym} -700 310 0 0 {name=Vin9 value=pulse(0,1.8,0,50ps,50ps,100ns,200ns)}
C {devices/vsource.sym} -670 340 0 0 {name=Vin10 value=pulse(1.8,0,0,50ps,50ps,100ns,200ns)}
C {devices/vsource.sym} -640 370 0 0 {name=Vin12 value=pulse(0,1.8,0,50ps,50ps,200ns,400ns)}
C {devices/vsource.sym} -610 400 0 0 {name=Vin1 value=pulse(1.8,0,0,50ps,50ps,200ns,400ns)}
C {devices/vsource.sym} -580 430 0 0 {name=Vin2 value=pulse(0,1.8,0,50ps,50ps,400ns,800ns)}
C {devices/vsource.sym} -550 460 0 0 {name=Vin3 value=pulse(1.8,0,0,50ps,50ps,400ns,800ns)}
C {devices/vsource.sym} -520 490 0 0 {name=Vin4 value=pulse(0,1.8,0,50ps,50ps,800ns,1600ns)}
C {devices/vsource.sym} -490 520 0 0 {name=Vin5 value=pulse(1.8,0,0,50ps,50ps,800ns,1600ns)}
C {devices/vsource.sym} -710 100 0 0 {name=Vdis0 value=pulse(0,1.8,2ns,50ps,50ps,20ns,100ns)}
C {devices/gnd.sym} -710 150 0 0 {name=l108 lab=GND}
C {devices/lab_pin.sym} -710 30 1 0 {name=l109 sig_type=std_logic lab=Dis0_S}
C {devices/gnd.sym} -710 -40 0 0 {name=l110 lab=GND}
C {devices/vsource.sym} -710 -90 0 0 {name=Vclk0 value=pulse(0,1.8,25ns,25ns,25ns,25ns,100ns)}
C {devices/lab_pin.sym} -710 -160 1 0 {name=l111 sig_type=std_logic lab=CLK0_S}
C {devices/vsource.sym} -670 130 0 0 {name=Vdis1 value=pulse(0,1.8,25ns,50ps,50ps,23ns,100ns)}
C {devices/gnd.sym} -670 180 0 0 {name=l112 lab=GND}
C {devices/lab_pin.sym} -670 60 1 0 {name=l113 sig_type=std_logic lab=Dis1_S}
C {devices/vsource.sym} -630 160 0 0 {name=Vdis2 value=pulse(0,1.8,50ns,50ps,50ps,23ns,100ns)}
C {devices/gnd.sym} -630 210 0 0 {name=l114 lab=GND}
C {devices/lab_pin.sym} -630 90 1 0 {name=l115 sig_type=std_logic lab=Dis2_S}
C {devices/vsource.sym} -590 190 0 0 {name=Vdis3 value=pulse(0,1.8,75ns,50ps,50ps,23ns,100ns)}
C {devices/gnd.sym} -590 240 0 0 {name=l116 lab=GND}
C {devices/lab_pin.sym} -590 120 1 0 {name=l117 sig_type=std_logic lab=Dis3_S}
C {devices/gnd.sym} -670 -10 0 0 {name=l118 lab=GND}
C {devices/vsource.sym} -670 -60 0 0 {name=Vclk1 value=pulse(0,1.8,-50ns,25ns,25ns,25ns,100ns)}
C {devices/lab_pin.sym} -670 -130 1 0 {name=l119 sig_type=std_logic lab=CLK1_S}
C {devices/gnd.sym} -630 20 0 0 {name=l120 lab=GND}
C {devices/vsource.sym} -630 -30 0 0 {name=Vclk2 value=pulse(0,1.8,-125ns,25ns,25ns,25ns,100ns)}
C {devices/lab_pin.sym} -630 -100 1 0 {name=l121 sig_type=std_logic lab=CLK2_S}
C {devices/gnd.sym} -590 50 0 0 {name=l122 lab=GND}
C {devices/vsource.sym} -590 0 0 0 {name=Vclk3 value=pulse(0,1.8,-200ns,25ns,25ns,25ns,100ns)}
C {devices/lab_pin.sym} -590 -70 1 0 {name=l123 sig_type=std_logic lab=CLK3_S}
C {devices/lab_pin.sym} -700 260 1 0 {name=l124 sig_type=std_logic lab=x0_bar_S}
C {devices/gnd.sym} -670 390 0 0 {name=l125 lab=GND}
C {devices/gnd.sym} -700 360 0 0 {name=l126 lab=GND}
C {devices/lab_pin.sym} -670 290 1 0 {name=l127 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} -640 320 1 0 {name=l128 sig_type=std_logic lab=x1_bar_S}
C {devices/gnd.sym} -610 440 0 0 {name=l129 lab=GND}
C {devices/gnd.sym} -640 420 0 0 {name=l130 lab=GND}
C {devices/lab_pin.sym} -610 350 1 0 {name=l131 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} -580 380 1 0 {name=l132 sig_type=std_logic lab=x2_bar_S}
C {devices/gnd.sym} -550 510 0 0 {name=l133 lab=GND}
C {devices/vsource.sym} -770 -840 0 0 {name=Vdis4 value=pulse(0,1.8,2ns,50ps,50ps,20ns,100ns)}
C {devices/gnd.sym} -770 -790 0 0 {name=l134 lab=GND}
C {devices/lab_pin.sym} -770 -910 1 0 {name=l135 sig_type=std_logic lab=Dis0}
C {devices/gnd.sym} -770 -980 0 0 {name=l136 lab=GND}
C {devices/vsource.sym} -770 -1030 0 0 {name=Vclk5 value=pulse(0,1.8,25ns,25ns,25ns,25ns,100ns)}
C {devices/lab_pin.sym} -770 -1100 1 0 {name=l137 sig_type=std_logic lab=CLK0}
C {devices/vsource.sym} -730 -810 0 0 {name=Vdis6 value=pulse(0,1.8,25ns,50ps,50ps,23ns,100ns)}
C {devices/gnd.sym} -730 -760 0 0 {name=l138 lab=GND}
C {devices/lab_pin.sym} -730 -880 1 0 {name=l139 sig_type=std_logic lab=Dis1}
C {devices/vsource.sym} -690 -780 0 0 {name=Vdis7 value=pulse(0,1.8,50ns,50ps,50ps,23ns,100ns)}
C {devices/gnd.sym} -690 -730 0 0 {name=l140 lab=GND}
C {devices/lab_pin.sym} -690 -850 1 0 {name=l141 sig_type=std_logic lab=Dis2}
C {devices/vsource.sym} -650 -750 0 0 {name=Vdis8 value=pulse(0,1.8,75ns,50ps,50ps,23ns,100ns)}
C {devices/gnd.sym} -650 -700 0 0 {name=l142 lab=GND}
C {devices/lab_pin.sym} -650 -820 1 0 {name=l143 sig_type=std_logic lab=Dis3}
C {devices/gnd.sym} -730 -950 0 0 {name=l144 lab=GND}
C {devices/vsource.sym} -730 -1000 0 0 {name=Vclk9 value=pulse(0,1.8,-50ns,25ns,25ns,25ns,100ns)}
C {devices/lab_pin.sym} -730 -1070 1 0 {name=l145 sig_type=std_logic lab=CLK1}
C {devices/gnd.sym} -690 -920 0 0 {name=l146 lab=GND}
C {devices/vsource.sym} -690 -970 0 0 {name=Vclk10 value=pulse(0,1.8,-125ns,25ns,25ns,25ns,100ns)}
C {devices/lab_pin.sym} -690 -1040 1 0 {name=l147 sig_type=std_logic lab=CLK2}
C {devices/gnd.sym} -650 -890 0 0 {name=l148 lab=GND}
C {devices/vsource.sym} -650 -940 0 0 {name=Vclk11 value=pulse(0,1.8,-200ns,25ns,25ns,25ns,100ns)}
C {devices/lab_pin.sym} -650 -1010 1 0 {name=l149 sig_type=std_logic lab=CLK3}
C {devices/lab_pin.sym} -770 -590 1 0 {name=l150 sig_type=std_logic lab=x0_bar}
C {devices/gnd.sym} -740 -460 0 0 {name=l151 lab=GND}
C {devices/gnd.sym} -770 -490 0 0 {name=l152 lab=GND}
C {devices/lab_pin.sym} -740 -560 1 0 {name=l153 sig_type=std_logic lab=x0}
C {devices/lab_pin.sym} -710 -530 1 0 {name=l154 sig_type=std_logic lab=x1_bar}
C {devices/gnd.sym} -680 -410 0 0 {name=l155 lab=GND}
C {devices/gnd.sym} -710 -430 0 0 {name=l156 lab=GND}
C {devices/lab_pin.sym} -680 -500 1 0 {name=l157 sig_type=std_logic lab=x1}
C {devices/lab_pin.sym} -650 -470 1 0 {name=l158 sig_type=std_logic lab=x2_bar}
C {devices/gnd.sym} -620 -340 0 0 {name=l159 lab=GND}
C {devices/gnd.sym} -650 -370 0 0 {name=l160 lab=GND}
C {devices/lab_pin.sym} -620 -440 1 0 {name=l161 sig_type=std_logic lab=x2}
C {devices/lab_pin.sym} -590 -410 1 0 {name=l162 sig_type=std_logic lab=x3_bar}
C {devices/gnd.sym} -560 -280 0 0 {name=l163 lab=GND}
C {devices/gnd.sym} -590 -310 0 0 {name=l164 lab=GND}
C {devices/lab_pin.sym} -560 -380 1 0 {name=l165 sig_type=std_logic lab=x3}
C {devices/vsource.sym} -770 -540 0 0 {name=Vin13 value=pulse(0,1.8,0,50ps,50ps,100ns,200ns)}
C {devices/vsource.sym} -740 -510 0 0 {name=Vin14 value=pulse(1.8,0,0,50ps,50ps,100ns,200ns)}
C {devices/vsource.sym} -710 -480 0 0 {name=Vin15 value=pulse(0,1.8,0,50ps,50ps,200ns,400ns)}
C {devices/vsource.sym} -680 -450 0 0 {name=Vin16 value=pulse(1.8,0,0,50ps,50ps,200ns,400ns)}
C {devices/vsource.sym} -650 -420 0 0 {name=Vin17 value=pulse(0,1.8,0,50ps,50ps,400ns,800ns)}
C {devices/vsource.sym} -620 -390 0 0 {name=Vin18 value=pulse(1.8,0,0,50ps,50ps,400ns,800ns)}
C {devices/vsource.sym} -590 -360 0 0 {name=Vin19 value=pulse(0,1.8,0,50ps,50ps,800ns,1600ns)}
C {devices/vsource.sym} -560 -330 0 0 {name=Vin20 value=pulse(1.8,0,0,50ps,50ps,800ns,1600ns)}
C {devices/lab_pin.sym} 1110 -880 2 0 {name=l166 sig_type=std_logic lab=AND2}
C {devices/lab_pin.sym} 1110 -660 2 0 {name=l167 sig_type=std_logic lab=AND3}
C {devices/lab_pin.sym} 1110 -860 2 0 {name=l168 sig_type=std_logic lab=NAND2}
C {devices/lab_pin.sym} 1110 -640 2 0 {name=l169 sig_type=std_logic lab=NAND3}
C {devices/lab_pin.sym} 600 -910 2 0 {name=l170 sig_type=std_logic lab=XNOR1}
C {devices/lab_pin.sym} 600 -620 2 0 {name=l171 sig_type=std_logic lab=AND1}
C {devices/lab_pin.sym} 600 -760 2 0 {name=l172 sig_type=std_logic lab=NOR1}
C {devices/lab_pin.sym} 600 -780 2 0 {name=l173 sig_type=std_logic lab=OR1}
C {devices/lab_pin.sym} 600 -930 2 0 {name=l174 sig_type=std_logic lab=XOR1}
C {devices/lab_pin.sym} 600 -600 2 0 {name=l175 sig_type=std_logic lab=NAND1}
C {EESPFAL_XOR_v3.sym} 430 -880 0 0 {name=x14}
C {EESPFAL_NOR_v3.sym} 430 -730 0 0 {name=x15}
C {EESPFAL_NOR_v3.sym} 1420 -740 0 0 {name=x16}
C {EESPFAL_NAND_v3.sym} 430 -570 0 0 {name=x17}
C {EESPFAL_NAND_v3.sym} 930 -610 0 0 {name=x18}
C {EESPFAL_NAND_v3.sym} 930 -830 0 0 {name=x19}
C {devices/lab_pin.sym} 750 -580 2 1 {name=l176 sig_type=std_logic lab=Dis1}
C {devices/lab_pin.sym} 750 -560 2 1 {name=l177 sig_type=std_logic lab=CLK1}
C {devices/gnd.sym} 1110 -620 0 0 {name=l178 lab=GND}
C {devices/gnd.sym} 1110 -840 0 0 {name=l179 lab=GND}
C {devices/gnd.sym} 610 -740 0 0 {name=l180 lab=GND}
C {devices/gnd.sym} 610 -580 0 0 {name=l181 lab=GND}
C {devices/gnd.sym} 610 -890 0 0 {name=l182 lab=GND}
C {devices/iopin.sym} 1590 -750 0 0 {name=p18 lab=GND}
C {devices/ipin.sym} 260 -930 0 0 {name=p19 lab=x0}
C {devices/ipin.sym} 260 -910 0 0 {name=p20 lab=x0_bar}
C {devices/ipin.sym} 260 -780 0 0 {name=p21 lab=x1}
C {devices/ipin.sym} 260 -760 0 0 {name=p22 lab=x1_bar}
C {devices/ipin.sym} 260 -720 0 0 {name=p23 lab=x2}
C {devices/ipin.sym} 260 -740 0 0 {name=p24 lab=x2_bar}
C {devices/ipin.sym} 260 -890 0 0 {name=p25 lab=x3}
C {devices/ipin.sym} 260 -870 0 0 {name=p26 lab=x3_bar}
C {devices/ipin.sym} 260 -830 0 0 {name=p27 lab=CLK0}
C {devices/ipin.sym} 260 -850 0 0 {name=p28 lab=Dis0}
C {devices/ipin.sym} 750 -780 0 0 {name=p29 lab=CLK1}
C {devices/ipin.sym} 1240 -710 0 0 {name=p30 lab=Dis2}
C {devices/ipin.sym} 1240 -690 0 0 {name=p31 lab=CLK2}
C {devices/ipin.sym} 750 -800 0 0 {name=p32 lab=Dis1}
C {devices/opin.sym} 1600 -790 0 0 {name=p33 lab=s0}
C {devices/opin.sym} 1600 -770 0 0 {name=p34 lab=s0_bar}
C {devices/lab_pin.sym} 260 -700 0 0 {name=l183 sig_type=std_logic lab=Dis0}
C {devices/lab_pin.sym} 260 -680 2 1 {name=l184 sig_type=std_logic lab=CLK0}
C {devices/lab_pin.sym} 260 -540 0 0 {name=l185 sig_type=std_logic lab=Dis0}
C {devices/lab_pin.sym} 260 -520 2 1 {name=l186 sig_type=std_logic lab=CLK0}
C {devices/lab_pin.sym} 260 -620 0 0 {name=l187 sig_type=std_logic lab=x2}
C {devices/lab_pin.sym} 260 -600 0 0 {name=l188 sig_type=std_logic lab=x2_bar}
C {devices/lab_pin.sym} 260 -580 0 0 {name=l189 sig_type=std_logic lab=x1_bar}
C {devices/lab_pin.sym} 260 -560 0 0 {name=l190 sig_type=std_logic lab=x1}
C {devices/gnd.sym} 1610 -730 0 0 {name=l191 lab=GND}
C {devices/lab_pin.sym} 260 -1060 0 0 {name=l192 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 260 -1120 0 0 {name=l193 sig_type=std_logic lab=Dis1_S}
C {devices/gnd.sym} 580 -1260 0 0 {name=l194 lab=GND}
C {devices/lab_pin.sym} 260 -1040 0 0 {name=l195 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 260 -1100 0 0 {name=l196 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 610 -1280 2 0 {name=l197 sig_type=std_logic lab=s0_bar_flat}
C {devices/lab_pin.sym} 610 -1300 2 0 {name=l198 sig_type=std_logic lab=s0_flat}
C {EESPFAL_s0_flat.sym} 430 -1170 0 0 {name=x20}
C {devices/lab_pin.sym} 260 -1300 0 0 {name=l199 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} 260 -1280 0 0 {name=l200 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} 260 -1180 0 0 {name=l201 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} 260 -1160 0 0 {name=l202 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} 260 -1140 0 0 {name=l203 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 260 -1080 2 1 {name=l204 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 260 -1240 0 0 {name=l205 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} 260 -1260 0 0 {name=l206 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} 260 -1200 0 0 {name=l207 sig_type=std_logic lab=x2_bar_S}
C {devices/lab_pin.sym} 260 -1220 0 0 {name=l208 sig_type=std_logic lab=x2_S}
C {devices/gnd.sym} 580 -1550 0 0 {name=l209 lab=GND}
C {devices/lab_pin.sym} 610 -1690 2 0 {name=l210 sig_type=std_logic lab=XOR0_bar_S}
C {devices/lab_pin.sym} 610 -1710 2 0 {name=l211 sig_type=std_logic lab=XOR0_S}
C {devices/lab_pin.sym} 260 -1710 0 0 {name=l212 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} 260 -1690 0 0 {name=l213 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} 260 -1470 0 0 {name=l214 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} 260 -1450 0 0 {name=l215 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} 260 -1390 0 0 {name=l216 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 260 -1370 2 1 {name=l217 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 260 -1610 0 0 {name=l218 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} 260 -1630 0 0 {name=l219 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} 260 -1530 0 0 {name=l220 sig_type=std_logic lab=x2_bar_S}
C {devices/lab_pin.sym} 260 -1550 0 0 {name=l221 sig_type=std_logic lab=x2_S}
C {EESPFAL_4in_XOR.sym} 430 -1540 0 0 {name=x21}
C {devices/lab_pin.sym} 610 -1650 2 0 {name=l222 sig_type=std_logic lab=XOR1_bar_S}
C {devices/lab_pin.sym} 610 -1670 2 0 {name=l223 sig_type=std_logic lab=XOR1_S}
C {devices/lab_pin.sym} 610 -1610 2 0 {name=l224 sig_type=std_logic lab=XOR2_bar_S}
C {devices/lab_pin.sym} 610 -1630 2 0 {name=l225 sig_type=std_logic lab=XOR2_S}
C {devices/lab_pin.sym} 610 -1570 2 0 {name=l226 sig_type=std_logic lab=XOR3_bar_S}
C {devices/lab_pin.sym} 610 -1590 2 0 {name=l227 sig_type=std_logic lab=XOR3_S}
C {devices/lab_pin.sym} 260 -1670 0 0 {name=l228 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} 260 -1590 0 0 {name=l229 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} 260 -1510 0 0 {name=l230 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} 260 -1430 0 0 {name=l231 sig_type=std_logic lab=k3_S}
C {devices/lab_pin.sym} 260 -1650 0 0 {name=l232 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} 260 -1570 0 0 {name=l233 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} 260 -1490 0 0 {name=l234 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} 260 -1410 0 0 {name=l235 sig_type=std_logic lab=k3_bar_S}
C {EESPFAL_XOR_v3.sym} 1140 -1380 0 0 {name=x22}
C {EESPFAL_XOR_v3.sym} 1140 -1080 0 0 {name=x23}
C {EESPFAL_XOR_v3.sym} 1140 -1230 0 0 {name=x24}
C {EESPFAL_XOR_v3.sym} 1140 -1530 0 0 {name=x25}
C {devices/lab_pin.sym} 970 -1050 0 0 {name=l236 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 970 -1030 2 1 {name=l237 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 970 -1200 0 0 {name=l238 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 970 -1180 2 1 {name=l239 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 970 -1350 0 0 {name=l240 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 970 -1330 2 1 {name=l241 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 970 -1500 0 0 {name=l242 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 970 -1480 2 1 {name=l243 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 970 -1580 0 0 {name=l244 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} 970 -1560 0 0 {name=l245 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} 970 -1540 0 0 {name=l246 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} 970 -1520 0 0 {name=l247 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} 970 -1410 0 0 {name=l248 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} 970 -1430 0 0 {name=l249 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} 970 -1390 0 0 {name=l250 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} 970 -1370 0 0 {name=l251 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} 970 -1260 0 0 {name=l252 sig_type=std_logic lab=x2_bar_S}
C {devices/lab_pin.sym} 970 -1280 0 0 {name=l253 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} 970 -1240 0 0 {name=l254 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} 970 -1220 0 0 {name=l255 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} 970 -1130 0 0 {name=l256 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} 970 -1110 0 0 {name=l257 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} 970 -1090 0 0 {name=l258 sig_type=std_logic lab=k3_S}
C {devices/lab_pin.sym} 970 -1070 0 0 {name=l259 sig_type=std_logic lab=k3_bar_S}
C {devices/gnd.sym} 1290 -1540 0 0 {name=l260 lab=GND}
C {devices/gnd.sym} 1290 -1390 0 0 {name=l261 lab=GND}
C {devices/gnd.sym} 1290 -1240 0 0 {name=l262 lab=GND}
C {devices/gnd.sym} 1290 -1090 0 0 {name=l263 lab=GND}
C {devices/lab_pin.sym} 1320 -1560 2 0 {name=l264 sig_type=std_logic lab=XOR0_bar_S}
C {devices/lab_pin.sym} 1320 -1580 2 0 {name=l265 sig_type=std_logic lab=XOR0_S}
C {devices/lab_pin.sym} 1320 -1410 2 0 {name=l266 sig_type=std_logic lab=XOR1_bar_S}
C {devices/lab_pin.sym} 1320 -1430 2 0 {name=l267 sig_type=std_logic lab=XOR1_S}
C {devices/lab_pin.sym} 1320 -1260 2 0 {name=l268 sig_type=std_logic lab=XOR2_bar_S}
C {devices/lab_pin.sym} 1320 -1280 2 0 {name=l269 sig_type=std_logic lab=XOR2_S}
C {devices/lab_pin.sym} 1320 -1110 2 0 {name=l270 sig_type=std_logic lab=XOR3_bar_S}
C {devices/lab_pin.sym} 1320 -1130 2 0 {name=l271 sig_type=std_logic lab=XOR3_S}
C {EESPFAL_4in_XOR.sym} 490 -1990 0 0 {name=x26}
C {EESPFAL_Sbox.sym} 900 -2030 0 0 {name=x27}
C {devices/gnd.sym} 640 -2000 0 0 {name=l272 lab=GND}
C {devices/gnd.sym} 1050 -2000 0 0 {name=l273 lab=GND}
C {devices/lab_pin.sym} 320 -2160 0 0 {name=l274 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} 320 -2140 0 0 {name=l275 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} 320 -1920 0 0 {name=l276 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} 320 -1900 0 0 {name=l277 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} 320 -1840 0 0 {name=l278 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 320 -1820 2 1 {name=l279 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 320 -2060 0 0 {name=l280 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} 320 -2080 0 0 {name=l281 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} 320 -1980 0 0 {name=l282 sig_type=std_logic lab=x2_bar_S}
C {devices/lab_pin.sym} 320 -2000 0 0 {name=l283 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} 320 -2120 0 0 {name=l284 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} 320 -2040 0 0 {name=l285 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} 320 -1960 0 0 {name=l286 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} 320 -1880 0 0 {name=l287 sig_type=std_logic lab=k3_S}
C {devices/lab_pin.sym} 320 -2100 0 0 {name=l288 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} 320 -2020 0 0 {name=l289 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} 320 -1940 0 0 {name=l290 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} 320 -1860 0 0 {name=l291 sig_type=std_logic lab=k3_bar_S}
C {devices/lab_pin.sym} 730 -1920 0 0 {name=l292 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 730 -1980 0 0 {name=l293 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 730 -1900 0 0 {name=l294 sig_type=std_logic lab=CLK3_S}
C {devices/lab_pin.sym} 730 -1960 0 0 {name=l295 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 730 -2000 0 0 {name=l296 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 730 -1940 2 1 {name=l297 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1070 -2160 2 0 {name=l298 sig_type=std_logic lab=s0_norm}
C {devices/lab_pin.sym} 1070 -2140 2 0 {name=l299 sig_type=std_logic lab=s0_bar_norm}
C {devices/lab_pin.sym} 1070 -2120 2 0 {name=l300 sig_type=std_logic lab=s1_norm}
C {devices/lab_pin.sym} 1070 -2100 2 0 {name=l301 sig_type=std_logic lab=s1_bar_norm}
C {devices/lab_pin.sym} 1070 -2080 2 0 {name=l302 sig_type=std_logic lab=s2_norm}
C {devices/lab_pin.sym} 1070 -2060 2 0 {name=l303 sig_type=std_logic lab=s2_bar_norm}
C {devices/lab_pin.sym} 1070 -2040 2 0 {name=l304 sig_type=std_logic lab=s3_norm}
C {devices/lab_pin.sym} 1070 -2020 2 0 {name=l305 sig_type=std_logic lab=s3_bar_norm}
C {devices/lab_pin.sym} 650 -2140 2 0 {name=l306 sig_type=std_logic lab=XOR0_bar_S}
C {devices/lab_pin.sym} 650 -2160 2 0 {name=l307 sig_type=std_logic lab=XOR0_S}
C {devices/lab_pin.sym} 650 -2100 2 0 {name=l308 sig_type=std_logic lab=XOR1_bar_S}
C {devices/lab_pin.sym} 650 -2120 2 0 {name=l309 sig_type=std_logic lab=XOR1_S}
C {devices/lab_pin.sym} 650 -2060 2 0 {name=l310 sig_type=std_logic lab=XOR2_bar_S}
C {devices/lab_pin.sym} 650 -2080 2 0 {name=l311 sig_type=std_logic lab=XOR2_S}
C {devices/lab_pin.sym} 650 -2020 2 0 {name=l312 sig_type=std_logic lab=XOR3_bar_S}
C {devices/lab_pin.sym} 650 -2040 2 0 {name=l313 sig_type=std_logic lab=XOR3_S}
C {devices/gnd.sym} 610 -2570 0 0 {name=l314 lab=GND}
C {devices/lab_pin.sym} 630 -2730 2 0 {name=l315 sig_type=std_logic lab=s0_norm}
C {devices/lab_pin.sym} 630 -2710 2 0 {name=l316 sig_type=std_logic lab=s0_bar_norm}
C {devices/lab_pin.sym} 630 -2690 2 0 {name=l317 sig_type=std_logic lab=s1_norm}
C {devices/lab_pin.sym} 630 -2670 2 0 {name=l318 sig_type=std_logic lab=s1_bar_norm}
C {devices/lab_pin.sym} 630 -2650 2 0 {name=l319 sig_type=std_logic lab=s2_norm}
C {devices/lab_pin.sym} 630 -2630 2 0 {name=l320 sig_type=std_logic lab=s2_bar_norm}
C {devices/lab_pin.sym} 630 -2610 2 0 {name=l321 sig_type=std_logic lab=s3_norm}
C {devices/lab_pin.sym} 630 -2590 2 0 {name=l322 sig_type=std_logic lab=s3_bar_norm}
C {EESPFAL_PRESENT80_R1.sym} 460 -2500 0 0 {name=x28}
C {devices/lab_pin.sym} 290 -2730 0 0 {name=l323 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} 290 -2710 0 0 {name=l324 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} 290 -2490 0 0 {name=l325 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} 290 -2470 0 0 {name=l326 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} 290 -2410 0 0 {name=l327 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 290 -2630 0 0 {name=l328 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} 290 -2650 0 0 {name=l329 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} 290 -2550 0 0 {name=l330 sig_type=std_logic lab=x2_bar_S}
C {devices/lab_pin.sym} 290 -2570 0 0 {name=l331 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} 290 -2690 0 0 {name=l332 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} 290 -2610 0 0 {name=l333 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} 290 -2530 0 0 {name=l334 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} 290 -2450 0 0 {name=l335 sig_type=std_logic lab=k3_S}
C {devices/lab_pin.sym} 290 -2670 0 0 {name=l336 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} 290 -2590 0 0 {name=l337 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} 290 -2510 0 0 {name=l338 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} 290 -2430 0 0 {name=l339 sig_type=std_logic lab=k3_bar_S}
C {devices/lab_pin.sym} 290 -2290 0 0 {name=l340 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 290 -2370 0 0 {name=l341 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 290 -2270 0 0 {name=l342 sig_type=std_logic lab=CLK3_S}
C {devices/lab_pin.sym} 290 -2350 0 0 {name=l343 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 290 -2390 0 0 {name=l344 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 290 -2310 2 1 {name=l345 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 290 -2330 2 1 {name=l346 sig_type=std_logic lab=CLK0_S}
C {devices/gnd.sym} -1160 -330 0 0 {name=l347 lab=GND}
C {devices/lab_pin.sym} -1130 -400 1 0 {name=l348 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} -1100 -370 1 0 {name=l349 sig_type=std_logic lab=x3_bar_S}
C {devices/gnd.sym} -1070 -240 0 0 {name=l350 lab=GND}
C {devices/gnd.sym} -1100 -270 0 0 {name=l351 lab=GND}
C {devices/lab_pin.sym} -1070 -340 1 0 {name=l352 sig_type=std_logic lab=x3_S}
C {devices/vsource.sym} -1280 -500 0 0 {name=Vin6 value=pulse(0,1.8,0,50ps,50ps,100ns,200ns)}
C {devices/vsource.sym} -1250 -470 0 0 {name=Vin7 value=pulse(1.8,0,0,50ps,50ps,100ns,200ns)}
C {devices/vsource.sym} -1220 -440 0 0 {name=Vin8 value=pulse(0,1.8,0,50ps,50ps,200ns,400ns)}
C {devices/vsource.sym} -1190 -410 0 0 {name=Vin11 value=pulse(1.8,0,0,50ps,50ps,200ns,400ns)}
C {devices/vsource.sym} -1160 -380 0 0 {name=Vin21 value=pulse(0,1.8,0,50ps,50ps,400ns,800ns)}
C {devices/vsource.sym} -1130 -350 0 0 {name=Vin22 value=pulse(1.8,0,0,50ps,50ps,400ns,800ns)}
C {devices/vsource.sym} -1100 -320 0 0 {name=Vin23 value=pulse(0,1.8,0,50ps,50ps,800ns,1600ns)}
C {devices/vsource.sym} -1070 -290 0 0 {name=Vin24 value=pulse(1.8,0,0,50ps,50ps,800ns,1600ns)}
C {devices/lab_pin.sym} -1280 -550 1 0 {name=l353 sig_type=std_logic lab=x0_bar_S}
C {devices/gnd.sym} -1250 -420 0 0 {name=l354 lab=GND}
C {devices/gnd.sym} -1280 -450 0 0 {name=l355 lab=GND}
C {devices/lab_pin.sym} -1250 -520 1 0 {name=l356 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} -1220 -490 1 0 {name=l357 sig_type=std_logic lab=x1_bar_S}
C {devices/gnd.sym} -1190 -370 0 0 {name=l358 lab=GND}
C {devices/gnd.sym} -1220 -390 0 0 {name=l359 lab=GND}
C {devices/lab_pin.sym} -1190 -460 1 0 {name=l360 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} -1160 -430 1 0 {name=l361 sig_type=std_logic lab=x2_bar_S}
C {devices/gnd.sym} -1130 -300 0 0 {name=l362 lab=GND}
C {EESPFAL_PRESENT80_R1_flat.sym} 1062.5 -2512.5 0 0 {name=x29}
C {devices/lab_pin.sym} 892.5 -2742.5 0 0 {name=l363 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} 892.5 -2722.5 0 0 {name=l364 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} 892.5 -2502.5 0 0 {name=l365 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} 892.5 -2482.5 0 0 {name=l366 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} 892.5 -2422.5 0 0 {name=l367 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 892.5 -2642.5 0 0 {name=l368 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} 892.5 -2662.5 0 0 {name=l369 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} 892.5 -2562.5 0 0 {name=l370 sig_type=std_logic lab=x2_bar_S}
C {devices/lab_pin.sym} 892.5 -2582.5 0 0 {name=l371 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} 892.5 -2702.5 0 0 {name=l372 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} 892.5 -2622.5 0 0 {name=l373 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} 892.5 -2542.5 0 0 {name=l374 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} 892.5 -2462.5 0 0 {name=l375 sig_type=std_logic lab=k3_S}
C {devices/lab_pin.sym} 892.5 -2682.5 0 0 {name=l376 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} 892.5 -2602.5 0 0 {name=l377 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} 892.5 -2522.5 0 0 {name=l378 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} 892.5 -2442.5 0 0 {name=l379 sig_type=std_logic lab=k3_bar_S}
C {devices/lab_pin.sym} 892.5 -2302.5 0 0 {name=l380 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 892.5 -2382.5 0 0 {name=l381 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 892.5 -2282.5 0 0 {name=l382 sig_type=std_logic lab=CLK3_S}
C {devices/lab_pin.sym} 892.5 -2362.5 0 0 {name=l383 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 892.5 -2402.5 0 0 {name=l384 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 892.5 -2322.5 2 1 {name=l385 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 892.5 -2342.5 2 1 {name=l386 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 1232.5 -2742.5 2 0 {name=l387 sig_type=std_logic lab=s0_flat}
C {devices/lab_pin.sym} 1232.5 -2722.5 2 0 {name=l388 sig_type=std_logic lab=s0_bar_flat}
C {devices/lab_pin.sym} 1232.5 -2702.5 2 0 {name=l389 sig_type=std_logic lab=s1_flat}
C {devices/lab_pin.sym} 1232.5 -2682.5 2 0 {name=l390 sig_type=std_logic lab=s1_bar_flat}
C {devices/lab_pin.sym} 1232.5 -2662.5 2 0 {name=l391 sig_type=std_logic lab=s2_flat}
C {devices/lab_pin.sym} 1232.5 -2642.5 2 0 {name=l392 sig_type=std_logic lab=s2_bar_flat}
C {devices/lab_pin.sym} 1232.5 -2622.5 2 0 {name=l393 sig_type=std_logic lab=s3_flat}
C {devices/lab_pin.sym} 1232.5 -2602.5 2 0 {name=l394 sig_type=std_logic lab=s3_bar_flat}
C {devices/gnd.sym} 1212.5 -2582.5 0 0 {name=l395 lab=GND}
C {devices/gnd.sym} -590 890 0 0 {name=l396 lab=GND}
C {devices/lab_pin.sym} -560 820 1 0 {name=l397 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} -530 850 1 0 {name=l398 sig_type=std_logic lab=x3_bar_S}
C {devices/gnd.sym} -500 980 0 0 {name=l399 lab=GND}
C {devices/gnd.sym} -530 950 0 0 {name=l400 lab=GND}
C {devices/lab_pin.sym} -500 880 1 0 {name=l401 sig_type=std_logic lab=x3_S}
C {devices/vsource.sym} -710 720 0 0 {name=Vin25 value=pulse(0,1.8,1ns,50ps,50ps,100ns,200ns)}
C {devices/vsource.sym} -680 750 0 0 {name=Vin26 value=pulse(1.8,0,1ns,50ps,50ps,100ns,200ns)}
C {devices/vsource.sym} -650 780 0 0 {name=Vin27 value=pulse(0,1.8,1ns,50ps,50ps,200ns,400ns)}
C {devices/vsource.sym} -620 810 0 0 {name=Vin28 value=pulse(1.8,0,1ns,50ps,50ps,200ns,400ns)}
C {devices/vsource.sym} -590 840 0 0 {name=Vin29 value=pulse(0,1.8,1ns,50ps,50ps,400ns,800ns)}
C {devices/vsource.sym} -560 870 0 0 {name=Vin30 value=pulse(1.8,0,1ns,50ps,50ps,400ns,800ns)}
C {devices/vsource.sym} -530 900 0 0 {name=Vin31 value=pulse(0,1.8,1ns,50ps,50ps,800ns,1600ns)}
C {devices/vsource.sym} -500 930 0 0 {name=Vin32 value=pulse(1.8,0,1ns,50ps,50ps,800ns,1600ns)}
C {devices/lab_pin.sym} -710 670 1 0 {name=l402 sig_type=std_logic lab=x0_bar_S}
C {devices/gnd.sym} -680 800 0 0 {name=l403 lab=GND}
C {devices/gnd.sym} -710 770 0 0 {name=l404 lab=GND}
C {devices/lab_pin.sym} -680 700 1 0 {name=l405 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} -650 730 1 0 {name=l406 sig_type=std_logic lab=x1_bar_S}
C {devices/gnd.sym} -620 850 0 0 {name=l407 lab=GND}
C {devices/gnd.sym} -650 830 0 0 {name=l408 lab=GND}
C {devices/lab_pin.sym} -620 760 1 0 {name=l409 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} -590 790 1 0 {name=l410 sig_type=std_logic lab=x2_bar_S}
C {devices/gnd.sym} -560 920 0 0 {name=l411 lab=GND}
C {devices/vsource.sym} -500 1140 0 0 {name=V4 value=0}
C {devices/gnd.sym} -620 1080 0 0 {name=l412 lab=GND}
C {devices/gnd.sym} -580 1110 0 0 {name=l413 lab=GND}
C {devices/gnd.sym} -540 1140 0 0 {name=l414 lab=GND}
C {devices/gnd.sym} -500 1170 0 0 {name=l415 lab=GND}
C {devices/lab_pin.sym} -620 1000 1 0 {name=l416 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} -580 1030 1 0 {name=l417 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} -540 1060 1 0 {name=l418 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} -500 1090 1 0 {name=l419 sig_type=std_logic lab=k3_S}
C {devices/vsource.sym} -510 1360 0 0 {name=V8 value=1.8}
C {devices/gnd.sym} -630 1300 0 0 {name=l420 lab=GND}
C {devices/gnd.sym} -590 1330 0 0 {name=l421 lab=GND}
C {devices/gnd.sym} -550 1360 0 0 {name=l422 lab=GND}
C {devices/gnd.sym} -510 1390 0 0 {name=l423 lab=GND}
C {devices/lab_pin.sym} -630 1220 1 0 {name=l424 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} -590 1250 1 0 {name=l425 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} -550 1280 1 0 {name=l426 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} -510 1310 1 0 {name=l427 sig_type=std_logic lab=k3_bar_S}
C {devices/vsource.sym} -620 1050 0 0 {name=V1 value=1.8}
C {devices/vsource.sym} -580 1080 0 0 {name=V2 value=1.8}
C {devices/vsource.sym} -540 1110 0 0 {name=V3 value=1.8}
C {devices/vsource.sym} -630 1270 0 0 {name=V5 value=0}
C {devices/vsource.sym} -590 1300 0 0 {name=V6 value=0}
C {devices/vsource.sym} -550 1330 0 0 {name=V7 value=0}
C {devices/code_shown.sym} 1790 -1480 0 0 {name=SPICE1 only_toplevel=false 
value= ".lib /research/pdk/open_pdks/share/pdk/sky130A/libs.tech/ngspice/sky130.lib.spice tt
**.include ~/magic_layout_stuff/EESPFAL_PRESENT80_R1.spice
**.include ~/magic_layout_stuff/EESPFAL_PRESENT80_R1_flat.spice
.param v0 ='0' v0_bar ='1.8' v1 ='0' v1_bar ='1.8' v2 ='0' v2_bar ='1.8' v3 ='0' v3_bar ='1.8'
.option method=gear 
.control

set tstart=0
*set tstop=0
let index=0
let index2=1
let wstart = $tstart
let wstop = 0n
let key = 0
let total_time = 32
let cycle_index = 50

foreach bit_index 0 1 2 3
	set bit = `./test.sh $&key $bit_index`
	alter Vk$bit_index = '$bit ? 1.8 : 0'
	alter Vk`echo $bit_index`_bar = '$bit ? 0 : 1.8'
end

set values_raw < circ_inputs_`echo $&cycle_index`.txt
compose values values $values_raw 
echo stuff

*let curr_time = index*40n

while index2 < length(values)
	let wstop = $&index2*40n
	stop when time=$&wstop
	let index2 = $&index2+1
	echo $&index2
end

let tstop = length(values)*40n
while index < length(values)
	let value = values[$&index]
	echo $&value 
	echo going into altering
	foreach bit_index 0 1 2 3
		set bit = `./test.sh $&value $bit_index`
		alter Vx$bit_index = '$bit ? 1.8 : 0'
		alter Vx`echo $bit_index`_bar = '$bit ? 0 : 1.8'
	end
	echo test stuff
	let index=index+1
	if index = 1
		tran 1n $&tstop 0 1n
	else	
		resume	
	end	
end

let index = 0
while index < length(values)
	let Pinst_CLK0_CLK3 = (v(CLK0_S)*i(vclk18))+(v(CLK1_S)*i(vclk22))+(v(CLK2_S)*i(vclk23))+(v(CLK3_S)*i(vclk24))
	*let Pinst_CLK0_CLK3_Dis0_Dis3 = (v(CLK0_S)*i(vclk18))+(v(CLK1_S)*i(vclk22))+(v(CLK2_S)*i(vclk23))+(v(CLK3_S)*i(vclk24))+(v(Dis0_S)*i(vdis17))+(v(Dis1_S)*i(vdis19))+(v(Dis2_S)*i(vdis20))+(v(Dis3_S)*i(vdis21))
	*plot Pinst_CLK0_CLK3
	let lin-tstart = $&index*40ns
	let lin-tstop = $&lin-tstart + 40ns
	let lin-tstep = 0.1n
	linearize Pinst
	*plot v(pinst)
	*display
	set appendwrite	
	wrdata EESPFAL_K`echo $&key`_`echo $&total_time`u_`echo $&cycle_index`cycle.csv Pinst_CLK0_CLK3
	*wrdata EESPFAL_K`echo $&key`_`echo $&total_time`u_`echo $&cycle_index`cycle.csv Pinst_CLK0_CLK3_Dis0_Dis3
	let index = index + 1
	*echo $plots
	setplot tran1
	destroy tran2 
	*echo $plots
end
*plot v(pinst)
.endc
"}
C {devices/gnd.sym} -1150 1110 0 0 {name=l428 lab=GND}
C {devices/gnd.sym} -1090 1170 0 0 {name=l429 lab=GND}
C {devices/gnd.sym} -1030 1230 0 0 {name=l430 lab=GND}
C {devices/gnd.sym} -970 1290 0 0 {name=l431 lab=GND}
C {devices/lab_pin.sym} -1150 1030 1 0 {name=l432 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} -1090 1090 1 0 {name=l433 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} -1030 1150 1 0 {name=l434 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} -970 1210 1 0 {name=l435 sig_type=std_logic lab=k3_S}
C {devices/gnd.sym} -1180 1080 0 0 {name=l436 lab=GND}
C {devices/gnd.sym} -1120 1140 0 0 {name=l437 lab=GND}
C {devices/gnd.sym} -1060 1200 0 0 {name=l438 lab=GND}
C {devices/gnd.sym} -1000 1260 0 0 {name=l439 lab=GND}
C {devices/lab_pin.sym} -1180 1000 1 0 {name=l440 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} -1120 1060 1 0 {name=l441 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} -1060 1120 1 0 {name=l442 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} -1000 1180 1 0 {name=l443 sig_type=std_logic lab=k3_bar_S}
C {devices/lab_pin.sym} -1020 790 1 0 {name=l444 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} -990 820 1 0 {name=l445 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} -960 850 1 0 {name=l446 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} -1170 640 1 0 {name=l447 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} -1110 700 1 0 {name=l448 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} -1080 730 1 0 {name=l449 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} -1050 760 1 0 {name=l450 sig_type=std_logic lab=x2_bar_S}
C {devices/vsource.sym} -1150 1080 0 0 {name=Vk0 value=1.8}
C {devices/vsource.sym} -1120 1110 0 0 {name=Vk1_bar value=0}
C {devices/vsource.sym} -1090 1140 0 0 {name=Vk1 value=1.8}
C {devices/vsource.sym} -1030 1200 0 0 {name=Vk2 value=0}
C {devices/gnd.sym} -1170 740 0 0 {name=l451 lab=GND}
C {devices/lab_pin.sym} -1140 670 1 0 {name=l452 sig_type=std_logic lab=x0_S}
C {devices/gnd.sym} -1140 770 0 0 {name=l453 lab=GND}
C {devices/gnd.sym} -1110 800 0 0 {name=l454 lab=GND}
C {devices/gnd.sym} -1080 820 0 0 {name=l455 lab=GND}
C {devices/gnd.sym} -1050 860 0 0 {name=l456 lab=GND}
C {devices/gnd.sym} -1020 880 0 0 {name=l457 lab=GND}
C {devices/gnd.sym} -990 920 0 0 {name=l458 lab=GND}
C {devices/gnd.sym} -960 940 0 0 {name=l459 lab=GND}
C {devices/vsource.sym} -1140 720 0 0 {name=Vx0 value=v0}
C {devices/vsource.sym} -1170 690 0 0 {name=Vx0_bar value=v0_bar}
C {devices/vsource.sym} -1050 810 0 0 {name=Vx2_bar value=v2_bar}
C {devices/vsource.sym} -1020 840 0 0 {name=Vx2 value=v2}
C {devices/vsource.sym} -1080 780 0 0 {name=Vx1 value=v1}
C {devices/vsource.sym} -1110 750 0 0 {name=Vx1_bar value=v1_bar}
C {devices/vsource.sym} -990 870 0 0 {name=Vx3_bar value=v3_bar}
C {devices/vsource.sym} -960 900 0 0 {name=Vx3 value=v3}
C {devices/vsource.sym} -970 1260 0 0 {name=Vk3 value=1.8}
C {devices/vsource.sym} -1180 1050 0 0 {name=Vk0_bar value=0}
C {devices/vsource.sym} -1060 1170 0 0 {name=Vk2_bar value=1.8}
C {devices/vsource.sym} -1000 1230 0 0 {name=Vk3_bar value=0}
C {devices/code_shown.sym} 1530 -2840 0 0 {name=SPICE2 only_toplevel=false 
value= ".lib /research/pdk/open_pdks/share/pdk/sky130A/libs.tech/ngspice/sky130.lib.spice tt
**.include ~/magic_layout_stuff/EESPFAL_PRESENT80_R1.spice
**.include ~/magic_layout_stuff/EESPFAL_PRESENT80_R1_flat.spice
**.include ~/magic_layout_stuff/EESPFAL_4in_XOR.spice
**.include ~/magic_layout_stuff/EESPFAL_Sbox.spice
**.include ~/magic_layout_stuff/EESPFAL_Sbox_flat.spice
.option method=gear MAXORD=3
.control
save all
tran 1n 2u
**plot v(s0_norm) v(s1_norm) v(s2_norm) v(s3_norm)
*plot v(s0_flat) v(s1_flat) v(s2_flat) v(s3_flat)
*plot v(s0_norm)
*plot v(s1_norm)
*plot v(s2_norm)
*plot v(s3_norm)
*plot v(s0_flat) 
*plot v(s1_flat) 
*plot v(s2_flat) 
*plot v(s3_flat)
plot v(CLK0_S) 
plot v(CLK1_S) 
plot v(CLK2_S) 
plot v(CLK3_S)
plot v(Dis0_S) 
plot v(Dis1_S) 
plot v(Dis2_S) 
plot v(Dis3_S)
*plot v(XOR0_S) v(XOR1_S) v(XOR2_S) v(XOR3_S)
*plot v(k0_S) v(k1_S) v(k2_S) v(k3_S)
**plot v(XOR0_S)
**plot v(XOR0_bar_S)
**plot v(XOR1_S)
**plot v(XOR1_bar_S)
**plot v(XOR2_S)
**plot v(XOR2_bar_S)
**plot v(XOR3_S)
**plot v(XOR3_bar_S)
**plot v(s0_flat)
**plot v(s1_flat)
**plot v(s2_flat)
**plot v(s3_flat)
**plot v(s0_bar_norm) v(s1_bar_norm) v(s2_bar_norm) v(s3_bar_norm)
**plot v(s0_bar_flat) v(s1_bar_flat) v(s2_bar_flat) v(s3_bar_flat)
**plot v(s0_bar_flat) v(s1_bar_flat) v(s2_bar_flat) v(s3_bar_flat)
*let Pinst_CLK0_CLK3 = (v(CLK0_S)*i(vclk18))+(v(CLK1_S)*i(vclk22))+(v(CLK2_S)*i(vclk23))+(v(CLK3_S)*i(vclk24))
**let Pinst_CLK0_CLK2_Dis0_Dis2 = (v(CLK0)*i(vclk0))+(v(Dis0)*i(Vdis0))+(v(CLK1)*i(vclk1))+(v(Dis1)*i(Vdis1))+(v(CLK2)*i(vclk2))+(v(Dis2)*i(Vdis2))
**plot Pinst_CLK0
*plot Pinst_CLK0_CLK3
**wrdata EESPFAL_PRESENT80R1_CLKs.raw v(CLK0_S) v(CLK1_S) v(CLK2_S) v(CLK3_S)
**wrdata EESPFAL_PRESENT80R1_X_inputs.raw v(XOR0_S) v(XOR1_S) v(XOR2_S) v(XOR3_S)
**wrdata EESPFAL_PRESENT80R1_K_inputs.raw v(k0_S) v(k1_S) v(k2_S) v(k3_S)
*wrdata EESPFAL_PRESENT80R1_InstPWR.raw Pinst_CLK0_CLK3
*wrdata EESPFAL_PRESENT80R1_InstPWR.csv Pinst_CLK0_CLK3
*wrdata EESPFAL_PRESENT80R1_InstPWR.tsv Pinst_CLK0_CLK3
**wrdata EESPFAL_PRESENT80_R1.raw v(s0_norm) v(s1_norm) v(s2_norm) v(s3_norm) v(s0_bar_norm) v(s1_bar_norm) v(s2_bar_norm) v(s3_bar_norm)
**wrdata EESPFAL_PRESENT80_R1_PEX.raw v(s0_flat) v(s1_flat) v(s2_flat) v(s3_flat) v(s0_bar_flat) v(s1_bar_flat) v(s2_bar_flat) v(s3_bar_flat) 
**wrdata EESPFAL_PRESENT80_R1.csv v(s0_norm) v(s1_norm) v(s2_norm) v(s3_norm) v(s0_bar_norm) v(s1_bar_norm) v(s2_bar_norm) v(s3_bar_norm)
*wrdata EESPFAL_PRESENT80_R1_PEX.csv v(s0_flat) v(s1_flat) v(s2_flat) v(s3_flat) v(s0_bar_flat) v(s1_bar_flat) v(s2_bar_flat) v(s3_bar_flat)
**wrdata EESPFAL_PRESENT80_R1_PEX_PWR.raw Pinst_CLK0_CLK3
**wrdata EESPFAL_PRESENT80_R1_PEX_PWR.csv Pinst_CLK0_CLK3
**wrdata EESPFAL_PRESENT80_R1.raw
.endc
"}
C {devices/gnd.sym} -660 2000 0 0 {name=l460 lab=GND}
C {devices/gnd.sym} -610 2000 0 0 {name=l461 lab=GND}
C {devices/gnd.sym} -560 2000 0 0 {name=l462 lab=GND}
C {devices/gnd.sym} -520 2000 0 0 {name=l463 lab=GND}
C {devices/lab_pin.sym} -660 1920 1 0 {name=l464 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} -610 1920 1 0 {name=l465 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} -560 1920 1 0 {name=l466 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} -520 1920 1 0 {name=l467 sig_type=std_logic lab=k3_S}
C {devices/gnd.sym} -660 2190 0 0 {name=l468 lab=GND}
C {devices/gnd.sym} -610 2190 0 0 {name=l469 lab=GND}
C {devices/gnd.sym} -560 2190 0 0 {name=l470 lab=GND}
C {devices/gnd.sym} -510 2190 0 0 {name=l471 lab=GND}
C {devices/lab_pin.sym} -660 2110 1 0 {name=l472 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} -610 2110 1 0 {name=l473 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} -560 2110 1 0 {name=l474 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} -510 2110 1 0 {name=l475 sig_type=std_logic lab=k3_bar_S}
C {devices/lab_pin.sym} -560 1540 1 0 {name=l476 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} -490 1750 1 0 {name=l477 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} -490 1540 1 0 {name=l478 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} -690 1750 1 0 {name=l479 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} -620 1750 1 0 {name=l480 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} -620 1540 1 0 {name=l481 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} -560 1750 1 0 {name=l482 sig_type=std_logic lab=x2_bar_S}
C {devices/vsource.sym} -660 1970 0 0 {name=Vk4 value=1.8}
C {devices/vsource.sym} -610 2160 0 0 {name=Vk5 value=0}
C {devices/vsource.sym} -610 1970 0 0 {name=Vk6 value=1.8}
C {devices/vsource.sym} -560 1970 0 0 {name=Vk7 value=0}
C {devices/gnd.sym} -690 1850 0 0 {name=l483 lab=GND}
C {devices/lab_pin.sym} -690 1540 1 0 {name=l484 sig_type=std_logic lab=x0_S}
C {devices/gnd.sym} -690 1640 0 0 {name=l485 lab=GND}
C {devices/gnd.sym} -620 1850 0 0 {name=l486 lab=GND}
C {devices/gnd.sym} -620 1630 0 0 {name=l487 lab=GND}
C {devices/gnd.sym} -560 1850 0 0 {name=l488 lab=GND}
C {devices/gnd.sym} -560 1630 0 0 {name=l489 lab=GND}
C {devices/gnd.sym} -490 1850 0 0 {name=l490 lab=GND}
C {devices/gnd.sym} -490 1630 0 0 {name=l491 lab=GND}
C {devices/vsource.sym} -690 1590 0 0 {name=Vx8 value=v0}
C {devices/vsource.sym} -690 1800 0 0 {name=Vx9 value=v0_bar}
C {devices/vsource.sym} -560 1800 0 0 {name=Vx10 value=v2_bar}
C {devices/vsource.sym} -560 1590 0 0 {name=Vx11 value=v2}
C {devices/vsource.sym} -620 1590 0 0 {name=Vx12 value=v1}
C {devices/vsource.sym} -620 1800 0 0 {name=Vx13 value=v1_bar}
C {devices/vsource.sym} -490 1800 0 0 {name=Vx14 value=v3_bar}
C {devices/vsource.sym} -490 1590 0 0 {name=Vx15 value=v3}
C {devices/vsource.sym} -520 1970 0 0 {name=Vk16 value=1.8}
C {devices/vsource.sym} -660 2160 0 0 {name=Vk17 value=0}
C {devices/vsource.sym} -560 2160 0 0 {name=Vk18 value=1.8}
C {devices/vsource.sym} -510 2160 0 0 {name=Vk19 value=0}
C {devices/lab_pin.sym} 260 800 0 0 {name=l492 sig_type=std_logic lab=x4_S}
C {devices/lab_pin.sym} 260 820 0 0 {name=l493 sig_type=std_logic lab=x4_bar_S}
C {devices/lab_pin.sym} 260 840 0 0 {name=l494 sig_type=std_logic lab=k4_S}
C {devices/lab_pin.sym} 260 860 0 0 {name=l495 sig_type=std_logic lab=k4_bar_S}
C {devices/lab_pin.sym} 260 880 0 0 {name=l496 sig_type=std_logic lab=x5_S}
C {devices/lab_pin.sym} 260 900 0 0 {name=l497 sig_type=std_logic lab=x5_bar_S}
C {devices/lab_pin.sym} 260 920 0 0 {name=l498 sig_type=std_logic lab=k5_S}
C {devices/lab_pin.sym} 260 940 0 0 {name=l499 sig_type=std_logic lab=k5_bar_S}
C {devices/lab_pin.sym} 260 960 0 0 {name=l500 sig_type=std_logic lab=x6_S}
C {devices/lab_pin.sym} 260 980 0 0 {name=l501 sig_type=std_logic lab=x6_bar_S}
C {devices/lab_pin.sym} 260 1000 0 0 {name=l502 sig_type=std_logic lab=k6_S}
C {devices/lab_pin.sym} 260 1020 0 0 {name=l503 sig_type=std_logic lab=k6_bar_S}
C {devices/lab_pin.sym} 260 1040 0 0 {name=l504 sig_type=std_logic lab=x7_S}
C {devices/lab_pin.sym} 260 1060 0 0 {name=l505 sig_type=std_logic lab=x7_bar_S}
C {devices/lab_pin.sym} 260 1080 0 0 {name=l506 sig_type=std_logic lab=k7_S}
C {devices/lab_pin.sym} 260 1100 0 0 {name=l507 sig_type=std_logic lab=k7_bar_S}
C {devices/lab_pin.sym} 260 1120 0 0 {name=l508 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 260 1140 0 0 {name=l509 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 260 1160 0 0 {name=l510 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 260 1180 0 0 {name=l511 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 260 1200 0 0 {name=l512 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 260 1220 0 0 {name=l513 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 260 1240 0 0 {name=l514 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 260 1260 0 0 {name=l515 sig_type=std_logic lab=CLK3_S}
C {devices/lab_pin.sym} 580 1780 0 0 {name=l517 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 580 1800 0 0 {name=l518 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 580 1820 0 0 {name=l519 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 580 1840 0 0 {name=l520 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 580 1860 0 0 {name=l521 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 580 1880 0 0 {name=l522 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 580 1900 0 0 {name=l523 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 580 1920 0 0 {name=l524 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 960 1620 0 0 {name=l525 lab=GND}
C {devices/capa.sym} 980 1390 2 0 {name=C17
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 980 1360 2 0 {name=l526 lab=GND}
C {devices/capa.sym} 1010 1390 2 0 {name=C18
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1010 1360 2 0 {name=l527 lab=GND}
C {devices/capa.sym} 1040 1390 2 0 {name=C19
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1040 1360 2 0 {name=l528 lab=GND}
C {devices/capa.sym} 1070 1390 2 0 {name=C20
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1070 1360 2 0 {name=l529 lab=GND}
C {devices/capa.sym} 1100 1390 2 0 {name=C21
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1100 1360 2 0 {name=l530 lab=GND}
C {devices/capa.sym} 1130 1390 2 0 {name=C22
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1130 1360 2 0 {name=l531 lab=GND}
C {devices/capa.sym} 1160 1390 2 0 {name=C23
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1160 1360 2 0 {name=l532 lab=GND}
C {devices/capa.sym} 1190 1390 2 0 {name=C24
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1190 1360 2 0 {name=l533 lab=GND}
C {devices/lab_pin.sym} 580 2020 0 0 {name=l534 sig_type=std_logic lab=x12_S}
C {devices/lab_pin.sym} 580 2040 0 0 {name=l535 sig_type=std_logic lab=x12_bar_S}
C {devices/lab_pin.sym} 580 2060 0 0 {name=l536 sig_type=std_logic lab=k12_S}
C {devices/lab_pin.sym} 580 2080 0 0 {name=l537 sig_type=std_logic lab=k12_bar_S}
C {devices/lab_pin.sym} 580 2100 0 0 {name=l538 sig_type=std_logic lab=x13_S}
C {devices/lab_pin.sym} 580 2120 0 0 {name=l539 sig_type=std_logic lab=x13_bar_S}
C {devices/lab_pin.sym} 580 2140 0 0 {name=l540 sig_type=std_logic lab=k13_S}
C {devices/lab_pin.sym} 580 2160 0 0 {name=l541 sig_type=std_logic lab=k13_bar_S}
C {devices/lab_pin.sym} 580 2180 0 0 {name=l542 sig_type=std_logic lab=x14_S}
C {devices/lab_pin.sym} 580 2200 0 0 {name=l543 sig_type=std_logic lab=x14_bar_S}
C {devices/lab_pin.sym} 580 2220 0 0 {name=l544 sig_type=std_logic lab=k14_S}
C {devices/lab_pin.sym} 580 2240 0 0 {name=l545 sig_type=std_logic lab=k14_bar_S}
C {devices/lab_pin.sym} 580 2260 0 0 {name=l546 sig_type=std_logic lab=x15_S}
C {devices/lab_pin.sym} 580 2280 0 0 {name=l547 sig_type=std_logic lab=x15_bar_S}
C {devices/lab_pin.sym} 580 2300 0 0 {name=l548 sig_type=std_logic lab=k15_S}
C {devices/lab_pin.sym} 580 2320 0 0 {name=l549 sig_type=std_logic lab=k15_bar_S}
C {devices/lab_pin.sym} 580 2340 0 0 {name=l550 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 580 2360 0 0 {name=l551 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 580 2380 0 0 {name=l552 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 580 2400 0 0 {name=l553 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 580 2420 0 0 {name=l554 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 580 2440 0 0 {name=l555 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 580 2460 0 0 {name=l556 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 580 2480 0 0 {name=l557 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 960 2180 0 0 {name=l558 lab=GND}
C {devices/capa.sym} 980 1950 2 0 {name=C25
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 980 1920 2 0 {name=l559 lab=GND}
C {devices/capa.sym} 1010 1950 2 0 {name=C26
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1010 1920 2 0 {name=l560 lab=GND}
C {devices/capa.sym} 1040 1950 2 0 {name=C27
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1040 1920 2 0 {name=l561 lab=GND}
C {devices/capa.sym} 1070 1950 2 0 {name=C28
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1070 1920 2 0 {name=l562 lab=GND}
C {devices/capa.sym} 1100 1950 2 0 {name=C29
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1100 1920 2 0 {name=l563 lab=GND}
C {devices/capa.sym} 1130 1950 2 0 {name=C30
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1130 1920 2 0 {name=l564 lab=GND}
C {devices/capa.sym} 1160 1950 2 0 {name=C31
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1160 1920 2 0 {name=l565 lab=GND}
C {devices/capa.sym} 1190 1950 2 0 {name=C32
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1190 1920 2 0 {name=l566 lab=GND}
C {devices/lab_pin.sym} 580 1460 0 0 {name=l705 sig_type=std_logic lab=x8_S}
C {devices/lab_pin.sym} 580 1480 0 0 {name=l706 sig_type=std_logic lab=x8_bar_S}
C {devices/lab_pin.sym} 580 1500 0 0 {name=l707 sig_type=std_logic lab="k8_S"}
C {devices/lab_pin.sym} 580 1520 0 0 {name=l708 sig_type=std_logic lab="k8_bar_S"}
C {devices/lab_pin.sym} 580 1540 0 0 {name=l709 sig_type=std_logic lab=x9_S}
C {devices/lab_pin.sym} 580 1560 0 0 {name=l710 sig_type=std_logic lab=x9_bar_S}
C {devices/lab_pin.sym} 580 1580 0 0 {name=l711 sig_type=std_logic lab=k9_S}
C {devices/lab_pin.sym} 580 1600 0 0 {name=l712 sig_type=std_logic lab=k9_bar_S}
C {devices/lab_pin.sym} 580 1620 0 0 {name=l713 sig_type=std_logic lab=x10_S}
C {devices/lab_pin.sym} 580 1640 0 0 {name=l714 sig_type=std_logic lab=x10_bar_S}
C {devices/lab_pin.sym} 580 1660 0 0 {name=l715 sig_type=std_logic lab=k10_S}
C {devices/lab_pin.sym} 580 1680 0 0 {name=l716 sig_type=std_logic lab=k10_bar_S}
C {devices/lab_pin.sym} 580 1700 0 0 {name=l717 sig_type=std_logic lab=x11_S}
C {devices/lab_pin.sym} 580 1720 0 0 {name=l718 sig_type=std_logic lab=x11_bar_S}
C {devices/lab_pin.sym} 580 1740 0 0 {name=l719 sig_type=std_logic lab=k11_S}
C {devices/lab_pin.sym} 580 1760 0 0 {name=l720 sig_type=std_logic lab=k11_bar_S}
C {devices/lab_pin.sym} 580 2570 0 0 {name=l567 sig_type=std_logic lab=x16_S}
C {devices/lab_pin.sym} 580 2590 0 0 {name=l568 sig_type=std_logic lab=x16_S_bar}
C {devices/lab_pin.sym} 580 2610 0 0 {name=l569 sig_type=std_logic lab=k16_S}
C {devices/lab_pin.sym} 580 2630 0 0 {name=l570 sig_type=std_logic lab=k16_S_bar}
C {devices/lab_pin.sym} 580 2650 0 0 {name=l571 sig_type=std_logic lab=x17_S}
C {devices/lab_pin.sym} 580 2670 0 0 {name=l572 sig_type=std_logic lab=x17_S_bar}
C {devices/lab_pin.sym} 580 2690 0 0 {name=l573 sig_type=std_logic lab=k17_S}
C {devices/lab_pin.sym} 580 2710 0 0 {name=l574 sig_type=std_logic lab=k17_S_bar}
C {devices/lab_pin.sym} 580 2730 0 0 {name=l575 sig_type=std_logic lab=x18_S}
C {devices/lab_pin.sym} 580 2750 0 0 {name=l576 sig_type=std_logic lab=x18_S_bar}
C {devices/lab_pin.sym} 580 2770 0 0 {name=l577 sig_type=std_logic lab=k18_S}
C {devices/lab_pin.sym} 580 2790 0 0 {name=l578 sig_type=std_logic lab=k18_S_bar}
C {devices/lab_pin.sym} 580 2810 0 0 {name=l579 sig_type=std_logic lab=x19_S}
C {devices/lab_pin.sym} 580 2830 0 0 {name=l580 sig_type=std_logic lab=x19_S_bar}
C {devices/lab_pin.sym} 580 2850 0 0 {name=l581 sig_type=std_logic lab=k19_S}
C {devices/lab_pin.sym} 580 2870 0 0 {name=l582 sig_type=std_logic lab=k19_S_bar}
C {devices/lab_pin.sym} 580 3120 0 0 {name=l583 sig_type=std_logic lab=x20_S}
C {devices/lab_pin.sym} 580 3140 0 0 {name=l584 sig_type=std_logic lab=x20_S_bar}
C {devices/lab_pin.sym} 580 3160 0 0 {name=l585 sig_type=std_logic lab=k20_S}
C {devices/lab_pin.sym} 580 3180 0 0 {name=l586 sig_type=std_logic lab=k20_S_bar}
C {devices/lab_pin.sym} 580 3200 0 0 {name=l587 sig_type=std_logic lab=x21_S}
C {devices/lab_pin.sym} 580 3220 0 0 {name=l588 sig_type=std_logic lab=x21_S_bar}
C {devices/lab_pin.sym} 580 3240 0 0 {name=l589 sig_type=std_logic lab=k21_S}
C {devices/lab_pin.sym} 580 3260 0 0 {name=l590 sig_type=std_logic lab=k21_S_bar}
C {devices/lab_pin.sym} 580 3280 0 0 {name=l591 sig_type=std_logic lab=x22_S}
C {devices/lab_pin.sym} 580 3300 0 0 {name=l592 sig_type=std_logic lab=x22_S_bar}
C {devices/lab_pin.sym} 580 3320 0 0 {name=l593 sig_type=std_logic lab=k22_S}
C {devices/lab_pin.sym} 580 3340 0 0 {name=l594 sig_type=std_logic lab=k22_S_bar}
C {devices/lab_pin.sym} 580 3360 0 0 {name=l595 sig_type=std_logic lab=x23_S}
C {devices/lab_pin.sym} 580 3380 0 0 {name=l596 sig_type=std_logic lab=x23_S_bar}
C {devices/lab_pin.sym} 580 3400 0 0 {name=l597 sig_type=std_logic lab=k23_S}
C {devices/lab_pin.sym} 580 3420 0 0 {name=l598 sig_type=std_logic lab=k23_S_bar}
C {devices/lab_pin.sym} 580 3670 0 0 {name=l599 sig_type=std_logic lab=x24_S}
C {devices/lab_pin.sym} 580 3690 0 0 {name=l600 sig_type=std_logic lab=x24_S_bar}
C {devices/lab_pin.sym} 580 3710 0 0 {name=l601 sig_type=std_logic lab=k24_S}
C {devices/lab_pin.sym} 580 3730 0 0 {name=l602 sig_type=std_logic lab=k24_S_bar}
C {devices/lab_pin.sym} 580 3750 0 0 {name=l603 sig_type=std_logic lab=x25_S}
C {devices/lab_pin.sym} 580 3770 0 0 {name=l604 sig_type=std_logic lab=x25_S_bar}
C {devices/lab_pin.sym} 580 3790 0 0 {name=l605 sig_type=std_logic lab=k25_S}
C {devices/lab_pin.sym} 580 3810 0 0 {name=l606 sig_type=std_logic lab=k25_S_bar}
C {devices/lab_pin.sym} 580 3830 0 0 {name=l607 sig_type=std_logic lab=x26_S}
C {devices/lab_pin.sym} 580 3850 0 0 {name=l608 sig_type=std_logic lab=x26_S_bar}
C {devices/lab_pin.sym} 580 3870 0 0 {name=l609 sig_type=std_logic lab=k26_S}
C {devices/lab_pin.sym} 580 3890 0 0 {name=l610 sig_type=std_logic lab=k26_S_bar}
C {devices/lab_pin.sym} 580 3910 0 0 {name=l611 sig_type=std_logic lab=x27_S}
C {devices/lab_pin.sym} 580 3930 0 0 {name=l612 sig_type=std_logic lab=x27_S_bar}
C {devices/lab_pin.sym} 580 3950 0 0 {name=l613 sig_type=std_logic lab=k27_S}
C {devices/lab_pin.sym} 580 3970 0 0 {name=l614 sig_type=std_logic lab=k27_S_bar}
C {devices/lab_pin.sym} 580 4220 0 0 {name=l615 sig_type=std_logic lab=x28_S}
C {devices/lab_pin.sym} 580 4240 0 0 {name=l616 sig_type=std_logic lab=x28_S_bar}
C {devices/lab_pin.sym} 580 4260 0 0 {name=l617 sig_type=std_logic lab=k28_S}
C {devices/lab_pin.sym} 580 4280 0 0 {name=l618 sig_type=std_logic lab=k28_S_bar}
C {devices/lab_pin.sym} 580 4300 0 0 {name=l619 sig_type=std_logic lab=x29_S}
C {devices/lab_pin.sym} 580 4320 0 0 {name=l620 sig_type=std_logic lab=x29_S_bar}
C {devices/lab_pin.sym} 580 4340 0 0 {name=l621 sig_type=std_logic lab=k29_S}
C {devices/lab_pin.sym} 580 4360 0 0 {name=l622 sig_type=std_logic lab=k29_S_bar}
C {devices/lab_pin.sym} 580 4380 0 0 {name=l623 sig_type=std_logic lab=x30_S}
C {devices/lab_pin.sym} 580 4400 0 0 {name=l624 sig_type=std_logic lab=x30_S_bar}
C {devices/lab_pin.sym} 580 4420 0 0 {name=l625 sig_type=std_logic lab=k30_S}
C {devices/lab_pin.sym} 580 4440 0 0 {name=l626 sig_type=std_logic lab=k30_S_bar}
C {devices/lab_pin.sym} 580 4460 0 0 {name=l627 sig_type=std_logic lab=x31_S}
C {devices/lab_pin.sym} 580 4480 0 0 {name=l628 sig_type=std_logic lab=x31_S_bar}
C {devices/lab_pin.sym} 580 4500 0 0 {name=l629 sig_type=std_logic lab=k31_S}
C {devices/lab_pin.sym} 580 4520 0 0 {name=l630 sig_type=std_logic lab=k31_S_bar}
C {devices/lab_pin.sym} 1920 800 0 0 {name=l631 sig_type=std_logic lab=x32_S}
C {devices/lab_pin.sym} 1920 820 0 0 {name=l632 sig_type=std_logic lab=x32_S_bar}
C {devices/lab_pin.sym} 1920 840 0 0 {name=l633 sig_type=std_logic lab=k32_S}
C {devices/lab_pin.sym} 1920 860 0 0 {name=l634 sig_type=std_logic lab=k32_S_bar}
C {devices/lab_pin.sym} 1920 880 0 0 {name=l635 sig_type=std_logic lab=x33_S}
C {devices/lab_pin.sym} 1920 900 0 0 {name=l636 sig_type=std_logic lab=x33_S_bar}
C {devices/lab_pin.sym} 1920 920 0 0 {name=l637 sig_type=std_logic lab=k33_S}
C {devices/lab_pin.sym} 1920 940 0 0 {name=l638 sig_type=std_logic lab=k33_S_bar}
C {devices/lab_pin.sym} 1920 960 0 0 {name=l639 sig_type=std_logic lab=x34_S}
C {devices/lab_pin.sym} 1920 980 0 0 {name=l640 sig_type=std_logic lab=x34_S_bar}
C {devices/lab_pin.sym} 1920 1000 0 0 {name=l641 sig_type=std_logic lab=k34_S}
C {devices/lab_pin.sym} 1920 1020 0 0 {name=l642 sig_type=std_logic lab=k34_S_bar}
C {devices/lab_pin.sym} 1920 1040 0 0 {name=l643 sig_type=std_logic lab=x35_S}
C {devices/lab_pin.sym} 1920 1060 0 0 {name=l644 sig_type=std_logic lab=x35_S_bar}
C {devices/lab_pin.sym} 1920 1080 0 0 {name=l645 sig_type=std_logic lab=k35_S}
C {devices/lab_pin.sym} 1920 1100 0 0 {name=l646 sig_type=std_logic lab=k35_S_bar}
C {devices/lab_pin.sym} 1920 1350 0 0 {name=l647 sig_type=std_logic lab=x36_S}
C {devices/lab_pin.sym} 1920 1370 0 0 {name=l648 sig_type=std_logic lab=x36_S_bar}
C {devices/lab_pin.sym} 1920 1390 0 0 {name=l649 sig_type=std_logic lab=k36_S}
C {devices/lab_pin.sym} 1920 1410 0 0 {name=l650 sig_type=std_logic lab=k36_S_bar}
C {devices/lab_pin.sym} 1920 1430 0 0 {name=l651 sig_type=std_logic lab=x37_S}
C {devices/lab_pin.sym} 1920 1450 0 0 {name=l652 sig_type=std_logic lab=x37_S_bar}
C {devices/lab_pin.sym} 1920 1470 0 0 {name=l653 sig_type=std_logic lab=k37_S}
C {devices/lab_pin.sym} 1920 1490 0 0 {name=l654 sig_type=std_logic lab=k37_S_bar}
C {devices/lab_pin.sym} 1920 1510 0 0 {name=l655 sig_type=std_logic lab=x38_S}
C {devices/lab_pin.sym} 1920 1530 0 0 {name=l656 sig_type=std_logic lab=x38_S_bar}
C {devices/lab_pin.sym} 1920 1550 0 0 {name=l657 sig_type=std_logic lab=k38_S}
C {devices/lab_pin.sym} 1920 1570 0 0 {name=l658 sig_type=std_logic lab=k38_S_bar}
C {devices/lab_pin.sym} 1920 1590 0 0 {name=l659 sig_type=std_logic lab=x39_S}
C {devices/lab_pin.sym} 1920 1610 0 0 {name=l660 sig_type=std_logic lab=x39_S_bar}
C {devices/lab_pin.sym} 1920 1630 0 0 {name=l661 sig_type=std_logic lab=k39_S}
C {devices/lab_pin.sym} 1920 1650 0 0 {name=l662 sig_type=std_logic lab=k39_S_bar}
C {devices/lab_pin.sym} 1920 1900 0 0 {name=l663 sig_type=std_logic lab=x40_S}
C {devices/lab_pin.sym} 1920 1920 0 0 {name=l664 sig_type=std_logic lab=x40_S_bar}
C {devices/lab_pin.sym} 1920 1940 0 0 {name=l665 sig_type=std_logic lab=k40_S}
C {devices/lab_pin.sym} 1920 1960 0 0 {name=l666 sig_type=std_logic lab=k40_S_bar}
C {devices/lab_pin.sym} 1920 1980 0 0 {name=l667 sig_type=std_logic lab=x41_S}
C {devices/lab_pin.sym} 1920 2000 0 0 {name=l668 sig_type=std_logic lab=x41_S_bar}
C {devices/lab_pin.sym} 1920 2020 0 0 {name=l669 sig_type=std_logic lab=k41_S}
C {devices/lab_pin.sym} 1920 2040 0 0 {name=l670 sig_type=std_logic lab=k41_S_bar}
C {devices/lab_pin.sym} 1920 2060 0 0 {name=l671 sig_type=std_logic lab=x42_S}
C {devices/lab_pin.sym} 1920 2080 0 0 {name=l672 sig_type=std_logic lab=x42_S_bar}
C {devices/lab_pin.sym} 1920 2100 0 0 {name=l673 sig_type=std_logic lab=k42_S}
C {devices/lab_pin.sym} 1920 2120 0 0 {name=l674 sig_type=std_logic lab=k42_S_bar}
C {devices/lab_pin.sym} 1920 2140 0 0 {name=l675 sig_type=std_logic lab=x43_S}
C {devices/lab_pin.sym} 1920 2160 0 0 {name=l676 sig_type=std_logic lab=x43_S_bar}
C {devices/lab_pin.sym} 1920 2180 0 0 {name=l677 sig_type=std_logic lab=k43_S}
C {devices/lab_pin.sym} 1920 2200 0 0 {name=l678 sig_type=std_logic lab=k43_S_bar}
C {devices/lab_pin.sym} 1920 2450 0 0 {name=l679 sig_type=std_logic lab=x44_S}
C {devices/lab_pin.sym} 1920 2470 0 0 {name=l680 sig_type=std_logic lab=x44_S_bar}
C {devices/lab_pin.sym} 1920 2490 0 0 {name=l681 sig_type=std_logic lab=k44_S}
C {devices/lab_pin.sym} 1920 2510 0 0 {name=l682 sig_type=std_logic lab=k44_S_bar}
C {devices/lab_pin.sym} 1920 2530 0 0 {name=l683 sig_type=std_logic lab=x45_S}
C {devices/lab_pin.sym} 1920 2550 0 0 {name=l684 sig_type=std_logic lab=x45_S_bar}
C {devices/lab_pin.sym} 1920 2570 0 0 {name=l685 sig_type=std_logic lab=k45_S}
C {devices/lab_pin.sym} 1920 2590 0 0 {name=l686 sig_type=std_logic lab=k45_S_bar}
C {devices/lab_pin.sym} 1920 2610 0 0 {name=l687 sig_type=std_logic lab=x46_S}
C {devices/lab_pin.sym} 1920 2630 0 0 {name=l688 sig_type=std_logic lab=x46_S_bar}
C {devices/lab_pin.sym} 1920 2650 0 0 {name=l689 sig_type=std_logic lab=k46_S}
C {devices/lab_pin.sym} 1920 2670 0 0 {name=l690 sig_type=std_logic lab=k46_S_bar}
C {devices/lab_pin.sym} 1920 2690 0 0 {name=l691 sig_type=std_logic lab=x47_S}
C {devices/lab_pin.sym} 1920 2710 0 0 {name=l692 sig_type=std_logic lab=x47_S_bar}
C {devices/lab_pin.sym} 1920 2730 0 0 {name=l693 sig_type=std_logic lab=k47_S}
C {devices/lab_pin.sym} 1920 2750 0 0 {name=l694 sig_type=std_logic lab=k47_S_bar}
C {devices/lab_pin.sym} 1920 2970 0 0 {name=l695 sig_type=std_logic lab=x48_S}
C {devices/lab_pin.sym} 1920 2990 0 0 {name=l696 sig_type=std_logic lab=x48_S_bar}
C {devices/lab_pin.sym} 1920 3010 0 0 {name=l697 sig_type=std_logic lab=k48_S}
C {devices/lab_pin.sym} 1920 3030 0 0 {name=l698 sig_type=std_logic lab=k48_S_bar}
C {devices/lab_pin.sym} 1920 3050 0 0 {name=l699 sig_type=std_logic lab=x49_S}
C {devices/lab_pin.sym} 1920 3070 0 0 {name=l700 sig_type=std_logic lab=x49_S_bar}
C {devices/lab_pin.sym} 1920 3090 0 0 {name=l701 sig_type=std_logic lab=k49_S}
C {devices/lab_pin.sym} 1920 3110 0 0 {name=l702 sig_type=std_logic lab=k49_S_bar}
C {devices/lab_pin.sym} 1920 3130 0 0 {name=l703 sig_type=std_logic lab=x50_S}
C {devices/lab_pin.sym} 1920 3150 0 0 {name=l704 sig_type=std_logic lab=x50_S_bar}
C {devices/lab_pin.sym} 1920 3170 0 0 {name=l721 sig_type=std_logic lab=k50_S}
C {devices/lab_pin.sym} 1920 3190 0 0 {name=l722 sig_type=std_logic lab=k50_S_bar}
C {devices/lab_pin.sym} 1920 3210 0 0 {name=l723 sig_type=std_logic lab=x51_S}
C {devices/lab_pin.sym} 1920 3230 0 0 {name=l724 sig_type=std_logic lab=x51_S_bar}
C {devices/lab_pin.sym} 1920 3250 0 0 {name=l725 sig_type=std_logic lab=k51_S}
C {devices/lab_pin.sym} 1920 3270 0 0 {name=l726 sig_type=std_logic lab=k51_S_bar}
C {devices/lab_pin.sym} 1920 3520 0 0 {name=l727 sig_type=std_logic lab=x52_S}
C {devices/lab_pin.sym} 1920 3540 0 0 {name=l728 sig_type=std_logic lab=x52_S_bar}
C {devices/lab_pin.sym} 1920 3560 0 0 {name=l729 sig_type=std_logic lab=k52_S}
C {devices/lab_pin.sym} 1920 3580 0 0 {name=l730 sig_type=std_logic lab=k52_S_bar}
C {devices/lab_pin.sym} 1920 3600 0 0 {name=l731 sig_type=std_logic lab=x53_S}
C {devices/lab_pin.sym} 1920 3620 0 0 {name=l732 sig_type=std_logic lab=x53_S_bar}
C {devices/lab_pin.sym} 1920 3640 0 0 {name=l733 sig_type=std_logic lab=k53_S}
C {devices/lab_pin.sym} 1920 3660 0 0 {name=l734 sig_type=std_logic lab=k53_S_bar}
C {devices/lab_pin.sym} 1920 3680 0 0 {name=l735 sig_type=std_logic lab=x54_S}
C {devices/lab_pin.sym} 1920 3700 0 0 {name=l736 sig_type=std_logic lab=x54_S_bar}
C {devices/lab_pin.sym} 1920 3720 0 0 {name=l737 sig_type=std_logic lab=k54_S}
C {devices/lab_pin.sym} 1920 3740 0 0 {name=l738 sig_type=std_logic lab=k54_S_bar}
C {devices/lab_pin.sym} 1920 3760 0 0 {name=l739 sig_type=std_logic lab=x55_S}
C {devices/lab_pin.sym} 1920 3780 0 0 {name=l740 sig_type=std_logic lab=x55_S_bar}
C {devices/lab_pin.sym} 1920 3800 0 0 {name=l741 sig_type=std_logic lab=k55_S}
C {devices/lab_pin.sym} 1920 3820 0 0 {name=l742 sig_type=std_logic lab=k55_S_bar}
C {devices/lab_pin.sym} 1920 4070 0 0 {name=l743 sig_type=std_logic lab=x56_S}
C {devices/lab_pin.sym} 1920 4090 0 0 {name=l744 sig_type=std_logic lab=x56_S_bar}
C {devices/lab_pin.sym} 1920 4110 0 0 {name=l745 sig_type=std_logic lab=k56_S}
C {devices/lab_pin.sym} 1920 4130 0 0 {name=l746 sig_type=std_logic lab=k56_S_bar}
C {devices/lab_pin.sym} 1920 4150 0 0 {name=l747 sig_type=std_logic lab=x57_S}
C {devices/lab_pin.sym} 1920 4170 0 0 {name=l748 sig_type=std_logic lab=x57_S_bar}
C {devices/lab_pin.sym} 1920 4190 0 0 {name=l749 sig_type=std_logic lab=k57_S}
C {devices/lab_pin.sym} 1920 4210 0 0 {name=l750 sig_type=std_logic lab=k57_S_bar}
C {devices/lab_pin.sym} 1920 4230 0 0 {name=l751 sig_type=std_logic lab=x58_S}
C {devices/lab_pin.sym} 1920 4250 0 0 {name=l752 sig_type=std_logic lab=x58_S_bar}
C {devices/lab_pin.sym} 1920 4270 0 0 {name=l753 sig_type=std_logic lab=k58_S}
C {devices/lab_pin.sym} 1920 4290 0 0 {name=l754 sig_type=std_logic lab=k58_S_bar}
C {devices/lab_pin.sym} 1920 4310 0 0 {name=l755 sig_type=std_logic lab=x59_S}
C {devices/lab_pin.sym} 1920 4330 0 0 {name=l756 sig_type=std_logic lab=x59_S_bar}
C {devices/lab_pin.sym} 1920 4350 0 0 {name=l757 sig_type=std_logic lab=k59_S}
C {devices/lab_pin.sym} 1920 4370 0 0 {name=l758 sig_type=std_logic lab=k59_S_bar}
C {devices/lab_pin.sym} 1920 4620 0 0 {name=l759 sig_type=std_logic lab=x60_S}
C {devices/lab_pin.sym} 1920 4640 0 0 {name=l760 sig_type=std_logic lab=x60_S_bar}
C {devices/lab_pin.sym} 1920 4660 0 0 {name=l761 sig_type=std_logic lab=k60_S}
C {devices/lab_pin.sym} 1920 4680 0 0 {name=l762 sig_type=std_logic lab=k60_S_bar}
C {devices/lab_pin.sym} 1920 4700 0 0 {name=l763 sig_type=std_logic lab=x61_S}
C {devices/lab_pin.sym} 1920 4720 0 0 {name=l764 sig_type=std_logic lab=x61_S_bar}
C {devices/lab_pin.sym} 1920 4740 0 0 {name=l765 sig_type=std_logic lab=k61_S}
C {devices/lab_pin.sym} 1920 4760 0 0 {name=l766 sig_type=std_logic lab=k61_S_bar}
C {devices/lab_pin.sym} 1920 4780 0 0 {name=l767 sig_type=std_logic lab=x62_S}
C {devices/lab_pin.sym} 1920 4800 0 0 {name=l768 sig_type=std_logic lab=x62_S_bar}
C {devices/lab_pin.sym} 1920 4820 0 0 {name=l769 sig_type=std_logic lab=k62_S}
C {devices/lab_pin.sym} 1920 4840 0 0 {name=l770 sig_type=std_logic lab=k62_S_bar}
C {devices/lab_pin.sym} 1920 4860 0 0 {name=l771 sig_type=std_logic lab=x63_S}
C {devices/lab_pin.sym} 1920 4880 0 0 {name=l772 sig_type=std_logic lab=x63_S_bar}
C {devices/lab_pin.sym} 1920 4900 0 0 {name=l773 sig_type=std_logic lab=k63_S}
C {devices/lab_pin.sym} 1920 4920 0 0 {name=l774 sig_type=std_logic lab=k63_S_bar}
C {devices/lab_pin.sym} 580 2890 0 0 {name=l775 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 580 2910 0 0 {name=l776 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 580 2930 0 0 {name=l777 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 580 2950 0 0 {name=l778 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 580 2970 0 0 {name=l779 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 580 2990 0 0 {name=l780 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 580 3010 0 0 {name=l781 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 580 3030 0 0 {name=l782 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 960 2730 0 0 {name=l783 lab=GND}
C {devices/capa.sym} 980 2500 2 0 {name=C33
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 980 2470 2 0 {name=l784 lab=GND}
C {devices/capa.sym} 1010 2500 2 0 {name=C34
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1010 2470 2 0 {name=l785 lab=GND}
C {devices/capa.sym} 1040 2500 2 0 {name=C35
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1040 2470 2 0 {name=l786 lab=GND}
C {devices/capa.sym} 1070 2500 2 0 {name=C36
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1070 2470 2 0 {name=l787 lab=GND}
C {devices/capa.sym} 1100 2500 2 0 {name=C37
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1100 2470 2 0 {name=l788 lab=GND}
C {devices/capa.sym} 1130 2500 2 0 {name=C38
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1130 2470 2 0 {name=l789 lab=GND}
C {devices/capa.sym} 1160 2500 2 0 {name=C39
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1160 2470 2 0 {name=l790 lab=GND}
C {devices/capa.sym} 1190 2500 2 0 {name=C40
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1190 2470 2 0 {name=l791 lab=GND}
C {devices/lab_pin.sym} 580 3440 0 0 {name=l792 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 580 3460 0 0 {name=l793 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 580 3480 0 0 {name=l794 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 580 3500 0 0 {name=l795 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 580 3520 0 0 {name=l796 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 580 3540 0 0 {name=l797 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 580 3560 0 0 {name=l798 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 580 3580 0 0 {name=l799 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 960 3280 0 0 {name=l800 lab=GND}
C {devices/capa.sym} 980 3050 2 0 {name=C41
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 980 3020 2 0 {name=l801 lab=GND}
C {devices/capa.sym} 1010 3050 2 0 {name=C42
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1010 3020 2 0 {name=l802 lab=GND}
C {devices/capa.sym} 1040 3050 2 0 {name=C43
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1040 3020 2 0 {name=l803 lab=GND}
C {devices/capa.sym} 1070 3050 2 0 {name=C44
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1070 3020 2 0 {name=l804 lab=GND}
C {devices/capa.sym} 1100 3050 2 0 {name=C45
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1100 3020 2 0 {name=l805 lab=GND}
C {devices/capa.sym} 1130 3050 2 0 {name=C46
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1130 3020 2 0 {name=l806 lab=GND}
C {devices/capa.sym} 1160 3050 2 0 {name=C47
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1160 3020 2 0 {name=l807 lab=GND}
C {devices/capa.sym} 1190 3050 2 0 {name=C48
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1190 3020 2 0 {name=l808 lab=GND}
C {devices/lab_pin.sym} 580 3990 0 0 {name=l809 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 580 4010 0 0 {name=l810 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 580 4030 0 0 {name=l811 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 580 4050 0 0 {name=l812 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 580 4070 0 0 {name=l813 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 580 4090 0 0 {name=l814 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 580 4110 0 0 {name=l815 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 580 4130 0 0 {name=l816 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 960 3830 0 0 {name=l817 lab=GND}
C {devices/capa.sym} 980 3600 2 0 {name=C49
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 980 3570 2 0 {name=l818 lab=GND}
C {devices/capa.sym} 1010 3600 2 0 {name=C50
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1010 3570 2 0 {name=l819 lab=GND}
C {devices/capa.sym} 1040 3600 2 0 {name=C51
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1040 3570 2 0 {name=l820 lab=GND}
C {devices/capa.sym} 1070 3600 2 0 {name=C52
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1070 3570 2 0 {name=l821 lab=GND}
C {devices/capa.sym} 1100 3600 2 0 {name=C53
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1100 3570 2 0 {name=l822 lab=GND}
C {devices/capa.sym} 1130 3600 2 0 {name=C54
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1130 3570 2 0 {name=l823 lab=GND}
C {devices/capa.sym} 1160 3600 2 0 {name=C55
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1160 3570 2 0 {name=l824 lab=GND}
C {devices/capa.sym} 1190 3600 2 0 {name=C56
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1190 3570 2 0 {name=l825 lab=GND}
C {devices/lab_pin.sym} 580 4540 0 0 {name=l826 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 580 4560 0 0 {name=l827 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 580 4580 0 0 {name=l828 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 580 4600 0 0 {name=l829 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 580 4620 0 0 {name=l830 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 580 4640 0 0 {name=l831 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 580 4660 0 0 {name=l832 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 580 4680 0 0 {name=l833 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 960 4380 0 0 {name=l834 lab=GND}
C {devices/capa.sym} 980 4150 2 0 {name=C57
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 980 4120 2 0 {name=l835 lab=GND}
C {devices/capa.sym} 1010 4150 2 0 {name=C58
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1010 4120 2 0 {name=l836 lab=GND}
C {devices/capa.sym} 1040 4150 2 0 {name=C59
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1040 4120 2 0 {name=l837 lab=GND}
C {devices/capa.sym} 1070 4150 2 0 {name=C60
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1070 4120 2 0 {name=l838 lab=GND}
C {devices/capa.sym} 1100 4150 2 0 {name=C61
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1100 4120 2 0 {name=l839 lab=GND}
C {devices/capa.sym} 1130 4150 2 0 {name=C62
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1130 4120 2 0 {name=l840 lab=GND}
C {devices/capa.sym} 1160 4150 2 0 {name=C63
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1160 4120 2 0 {name=l841 lab=GND}
C {devices/capa.sym} 1190 4150 2 0 {name=C64
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 1190 4120 2 0 {name=l842 lab=GND}
C {devices/lab_pin.sym} 1920 1120 0 0 {name=l843 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 1920 1140 0 0 {name=l844 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 1920 1160 0 0 {name=l845 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 1920 1180 0 0 {name=l846 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 1920 1200 0 0 {name=l847 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 1920 1220 0 0 {name=l848 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1920 1240 0 0 {name=l849 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 1920 1260 0 0 {name=l850 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 2300 960 0 0 {name=l851 lab=GND}
C {devices/capa.sym} 2320 730 2 0 {name=C65
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2320 700 2 0 {name=l852 lab=GND}
C {devices/capa.sym} 2350 730 2 0 {name=C66
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2350 700 2 0 {name=l853 lab=GND}
C {devices/capa.sym} 2380 730 2 0 {name=C67
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2380 700 2 0 {name=l854 lab=GND}
C {devices/capa.sym} 2410 730 2 0 {name=C68
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2410 700 2 0 {name=l855 lab=GND}
C {devices/capa.sym} 2440 730 2 0 {name=C69
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2440 700 2 0 {name=l856 lab=GND}
C {devices/capa.sym} 2470 730 2 0 {name=C70
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2470 700 2 0 {name=l857 lab=GND}
C {devices/capa.sym} 2500 730 2 0 {name=C71
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2500 700 2 0 {name=l858 lab=GND}
C {devices/capa.sym} 2530 730 2 0 {name=C72
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2530 700 2 0 {name=l859 lab=GND}
C {devices/lab_pin.sym} 1920 1670 0 0 {name=l860 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 1920 1690 0 0 {name=l861 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 1920 1710 0 0 {name=l862 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 1920 1730 0 0 {name=l863 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 1920 1750 0 0 {name=l864 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 1920 1770 0 0 {name=l865 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1920 1790 0 0 {name=l866 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 1920 1810 0 0 {name=l867 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 2300 1510 0 0 {name=l868 lab=GND}
C {devices/capa.sym} 2320 1280 2 0 {name=C73
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2320 1250 2 0 {name=l869 lab=GND}
C {devices/capa.sym} 2350 1280 2 0 {name=C74
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2350 1250 2 0 {name=l870 lab=GND}
C {devices/capa.sym} 2380 1280 2 0 {name=C75
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2380 1250 2 0 {name=l871 lab=GND}
C {devices/capa.sym} 2410 1280 2 0 {name=C76
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2410 1250 2 0 {name=l872 lab=GND}
C {devices/capa.sym} 2440 1280 2 0 {name=C77
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2440 1250 2 0 {name=l873 lab=GND}
C {devices/capa.sym} 2470 1280 2 0 {name=C78
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2470 1250 2 0 {name=l874 lab=GND}
C {devices/capa.sym} 2500 1280 2 0 {name=C79
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2500 1250 2 0 {name=l875 lab=GND}
C {devices/capa.sym} 2530 1280 2 0 {name=C80
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2530 1250 2 0 {name=l876 lab=GND}
C {devices/lab_pin.sym} 1920 2220 0 0 {name=l877 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 1920 2240 0 0 {name=l878 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 1920 2260 0 0 {name=l879 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 1920 2280 0 0 {name=l880 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 1920 2300 0 0 {name=l881 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 1920 2320 0 0 {name=l882 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1920 2340 0 0 {name=l883 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 1920 2360 0 0 {name=l884 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 2300 2060 0 0 {name=l885 lab=GND}
C {devices/capa.sym} 2320 1830 2 0 {name=C81
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2320 1800 2 0 {name=l886 lab=GND}
C {devices/capa.sym} 2350 1830 2 0 {name=C82
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2350 1800 2 0 {name=l887 lab=GND}
C {devices/capa.sym} 2380 1830 2 0 {name=C83
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2380 1800 2 0 {name=l888 lab=GND}
C {devices/capa.sym} 2410 1830 2 0 {name=C84
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2410 1800 2 0 {name=l889 lab=GND}
C {devices/capa.sym} 2440 1830 2 0 {name=C85
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2440 1800 2 0 {name=l890 lab=GND}
C {devices/capa.sym} 2470 1830 2 0 {name=C86
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2470 1800 2 0 {name=l891 lab=GND}
C {devices/capa.sym} 2500 1830 2 0 {name=C87
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2500 1800 2 0 {name=l892 lab=GND}
C {devices/capa.sym} 2530 1830 2 0 {name=C88
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2530 1800 2 0 {name=l893 lab=GND}
C {devices/lab_pin.sym} 1920 2770 0 0 {name=l894 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 1920 2790 0 0 {name=l895 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 1920 2810 0 0 {name=l896 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 1920 2830 0 0 {name=l897 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 1920 2850 0 0 {name=l898 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 1920 2870 0 0 {name=l899 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1920 2890 0 0 {name=l900 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 1920 2910 0 0 {name=l901 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 2300 2610 0 0 {name=l902 lab=GND}
C {devices/capa.sym} 2320 2380 2 0 {name=C89
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2320 2350 2 0 {name=l903 lab=GND}
C {devices/capa.sym} 2350 2380 2 0 {name=C90
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2350 2350 2 0 {name=l904 lab=GND}
C {devices/capa.sym} 2380 2380 2 0 {name=C91
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2380 2350 2 0 {name=l905 lab=GND}
C {devices/capa.sym} 2410 2380 2 0 {name=C92
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2410 2350 2 0 {name=l906 lab=GND}
C {devices/capa.sym} 2440 2380 2 0 {name=C93
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2440 2350 2 0 {name=l907 lab=GND}
C {devices/capa.sym} 2470 2380 2 0 {name=C94
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2470 2350 2 0 {name=l908 lab=GND}
C {devices/capa.sym} 2500 2380 2 0 {name=C95
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2500 2350 2 0 {name=l909 lab=GND}
C {devices/capa.sym} 2530 2380 2 0 {name=C96
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2530 2350 2 0 {name=l910 lab=GND}
C {devices/lab_pin.sym} 1920 3290 0 0 {name=l911 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 1920 3310 0 0 {name=l912 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 1920 3330 0 0 {name=l913 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 1920 3350 0 0 {name=l914 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 1920 3370 0 0 {name=l915 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 1920 3390 0 0 {name=l916 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1920 3410 0 0 {name=l917 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 1920 3430 0 0 {name=l918 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 2300 3130 0 0 {name=l919 lab=GND}
C {devices/capa.sym} 2320 2900 2 0 {name=C97
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2320 2870 2 0 {name=l920 lab=GND}
C {devices/capa.sym} 2350 2900 2 0 {name=C98
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2350 2870 2 0 {name=l921 lab=GND}
C {devices/capa.sym} 2380 2900 2 0 {name=C99
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2380 2870 2 0 {name=l922 lab=GND}
C {devices/capa.sym} 2410 2900 2 0 {name=C100
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2410 2870 2 0 {name=l923 lab=GND}
C {devices/capa.sym} 2440 2900 2 0 {name=C101
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2440 2870 2 0 {name=l924 lab=GND}
C {devices/capa.sym} 2470 2900 2 0 {name=C102
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2470 2870 2 0 {name=l925 lab=GND}
C {devices/capa.sym} 2500 2900 2 0 {name=C103
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2500 2870 2 0 {name=l926 lab=GND}
C {devices/capa.sym} 2530 2900 2 0 {name=C104
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2530 2870 2 0 {name=l927 lab=GND}
C {devices/lab_pin.sym} 1920 3840 0 0 {name=l928 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 1920 3860 0 0 {name=l929 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 1920 3880 0 0 {name=l930 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 1920 3900 0 0 {name=l931 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 1920 3920 0 0 {name=l932 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 1920 3940 0 0 {name=l933 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1920 3960 0 0 {name=l934 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 1920 3980 0 0 {name=l935 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 2300 3680 0 0 {name=l936 lab=GND}
C {devices/capa.sym} 2320 3450 2 0 {name=C105
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2320 3420 2 0 {name=l937 lab=GND}
C {devices/capa.sym} 2350 3450 2 0 {name=C106
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2350 3420 2 0 {name=l938 lab=GND}
C {devices/capa.sym} 2380 3450 2 0 {name=C107
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2380 3420 2 0 {name=l939 lab=GND}
C {devices/capa.sym} 2410 3450 2 0 {name=C108
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2410 3420 2 0 {name=l940 lab=GND}
C {devices/capa.sym} 2440 3450 2 0 {name=C109
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2440 3420 2 0 {name=l941 lab=GND}
C {devices/capa.sym} 2470 3450 2 0 {name=C110
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2470 3420 2 0 {name=l942 lab=GND}
C {devices/capa.sym} 2500 3450 2 0 {name=C111
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2500 3420 2 0 {name=l943 lab=GND}
C {devices/capa.sym} 2530 3450 2 0 {name=C112
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2530 3420 2 0 {name=l944 lab=GND}
C {devices/lab_pin.sym} 1920 4390 0 0 {name=l945 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 1920 4410 0 0 {name=l946 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 1920 4430 0 0 {name=l947 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 1920 4450 0 0 {name=l948 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 1920 4470 0 0 {name=l949 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 1920 4490 0 0 {name=l950 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1920 4510 0 0 {name=l951 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 1920 4530 0 0 {name=l952 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 2300 4230 0 0 {name=l953 lab=GND}
C {devices/capa.sym} 2320 4000 2 0 {name=C113
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2320 3970 2 0 {name=l954 lab=GND}
C {devices/capa.sym} 2350 4000 2 0 {name=C114
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2350 3970 2 0 {name=l955 lab=GND}
C {devices/capa.sym} 2380 4000 2 0 {name=C115
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2380 3970 2 0 {name=l956 lab=GND}
C {devices/capa.sym} 2410 4000 2 0 {name=C116
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2410 3970 2 0 {name=l957 lab=GND}
C {devices/capa.sym} 2440 4000 2 0 {name=C117
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2440 3970 2 0 {name=l958 lab=GND}
C {devices/capa.sym} 2470 4000 2 0 {name=C118
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2470 3970 2 0 {name=l959 lab=GND}
C {devices/capa.sym} 2500 4000 2 0 {name=C119
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2500 3970 2 0 {name=l960 lab=GND}
C {devices/capa.sym} 2530 4000 2 0 {name=C120
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2530 3970 2 0 {name=l961 lab=GND}
C {devices/lab_pin.sym} 1920 4940 0 0 {name=l962 sig_type=std_logic lab=Dis0_S}
C {devices/lab_pin.sym} 1920 4960 0 0 {name=l963 sig_type=std_logic lab=Dis1_S}
C {devices/lab_pin.sym} 1920 4980 0 0 {name=l964 sig_type=std_logic lab=Dis2_S}
C {devices/lab_pin.sym} 1920 5000 0 0 {name=l965 sig_type=std_logic lab=Dis3_S}
C {devices/lab_pin.sym} 1920 5020 0 0 {name=l966 sig_type=std_logic lab=CLK0_S}
C {devices/lab_pin.sym} 1920 5040 0 0 {name=l967 sig_type=std_logic lab=CLK1_S}
C {devices/lab_pin.sym} 1920 5060 0 0 {name=l968 sig_type=std_logic lab=CLK2_S}
C {devices/lab_pin.sym} 1920 5080 0 0 {name=l969 sig_type=std_logic lab=CLK3_S}
C {devices/gnd.sym} 2300 4780 0 0 {name=l970 lab=GND}
C {devices/capa.sym} 2320 4550 2 0 {name=C121
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2320 4520 2 0 {name=l971 lab=GND}
C {devices/capa.sym} 2350 4550 2 0 {name=C122
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2350 4520 2 0 {name=l972 lab=GND}
C {devices/capa.sym} 2380 4550 2 0 {name=C123
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2380 4520 2 0 {name=l973 lab=GND}
C {devices/capa.sym} 2410 4550 2 0 {name=C124
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2410 4520 2 0 {name=l974 lab=GND}
C {devices/capa.sym} 2440 4550 2 0 {name=C125
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2440 4520 2 0 {name=l975 lab=GND}
C {devices/capa.sym} 2470 4550 2 0 {name=C126
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2470 4520 2 0 {name=l976 lab=GND}
C {devices/capa.sym} 2500 4550 2 0 {name=C127
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2500 4520 2 0 {name=l977 lab=GND}
C {devices/capa.sym} 2530 4550 2 0 {name=C128
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 2530 4520 2 0 {name=l978 lab=GND}
C {devices/lab_pin.sym} 1210 1460 0 1 {name=l987 sig_type=std_logic lab=s8_norm}
C {devices/lab_pin.sym} 1210 1480 0 1 {name=l988 sig_type=std_logic lab=s8_norm_bar}
C {devices/lab_pin.sym} 1210 1500 0 1 {name=l989 sig_type=std_logic lab=s9_norm}
C {devices/lab_pin.sym} 1210 1520 0 1 {name=l990 sig_type=std_logic lab=s9_norm_bar}
C {devices/lab_pin.sym} 1210 1540 0 1 {name=l991 sig_type=std_logic lab=s10_norm}
C {devices/lab_pin.sym} 1210 1560 0 1 {name=l992 sig_type=std_logic lab=s10_norm_bar}
C {devices/lab_pin.sym} 1210 1580 0 1 {name=l993 sig_type=std_logic lab=s11_norm}
C {devices/lab_pin.sym} 1210 1600 0 1 {name=l994 sig_type=std_logic lab=s11_norm_bar}
C {devices/lab_pin.sym} 1210 2020 0 1 {name=l995 sig_type=std_logic lab=s12_norm}
C {devices/lab_pin.sym} 1210 2040 0 1 {name=l996 sig_type=std_logic lab=s12_norm_bar}
C {devices/lab_pin.sym} 1210 2060 0 1 {name=l997 sig_type=std_logic lab=s13_norm}
C {devices/lab_pin.sym} 1210 2080 0 1 {name=l998 sig_type=std_logic lab=s13_norm_bar}
C {devices/lab_pin.sym} 1210 2100 0 1 {name=l999 sig_type=std_logic lab=s14_norm}
C {devices/lab_pin.sym} 1210 2120 0 1 {name=l1000 sig_type=std_logic lab=s14_norm_bar}
C {devices/lab_pin.sym} 1210 2140 0 1 {name=l1001 sig_type=std_logic lab=s15_norm}
C {devices/lab_pin.sym} 1210 2160 0 1 {name=l1002 sig_type=std_logic lab=s15_norm_bar}
C {devices/lab_pin.sym} 1210 2570 0 1 {name=l1003 sig_type=std_logic lab=s16_norm}
C {devices/lab_pin.sym} 1210 2590 0 1 {name=l1004 sig_type=std_logic lab=s16_norm_bar}
C {devices/lab_pin.sym} 1210 2610 0 1 {name=l1005 sig_type=std_logic lab=s17_norm}
C {devices/lab_pin.sym} 1210 2630 0 1 {name=l1006 sig_type=std_logic lab=s17_norm_bar}
C {devices/lab_pin.sym} 1210 2650 0 1 {name=l1007 sig_type=std_logic lab=s18_norm}
C {devices/lab_pin.sym} 1210 2670 0 1 {name=l1008 sig_type=std_logic lab=s18_norm_bar}
C {devices/lab_pin.sym} 1210 2690 0 1 {name=l1009 sig_type=std_logic lab=s19_norm}
C {devices/lab_pin.sym} 1210 2710 0 1 {name=l1010 sig_type=std_logic lab=s19_norm_bar}
C {devices/lab_pin.sym} 1210 3120 0 1 {name=l1011 sig_type=std_logic lab=s20_norm}
C {devices/lab_pin.sym} 1210 3140 0 1 {name=l1012 sig_type=std_logic lab=s20_norm_bar}
C {devices/lab_pin.sym} 1210 3160 0 1 {name=l1013 sig_type=std_logic lab=s21_norm}
C {devices/lab_pin.sym} 1210 3180 0 1 {name=l1014 sig_type=std_logic lab=s21_norm_bar}
C {devices/lab_pin.sym} 1210 3200 0 1 {name=l1015 sig_type=std_logic lab=s22_norm}
C {devices/lab_pin.sym} 1210 3220 0 1 {name=l1016 sig_type=std_logic lab=s22_norm_bar}
C {devices/lab_pin.sym} 1210 3240 0 1 {name=l1017 sig_type=std_logic lab=s23_norm}
C {devices/lab_pin.sym} 1210 3260 0 1 {name=l1018 sig_type=std_logic lab=s23_norm_bar}
C {devices/lab_pin.sym} 1210 3670 0 1 {name=l1019 sig_type=std_logic lab=s24_norm}
C {devices/lab_pin.sym} 1210 3690 0 1 {name=l1020 sig_type=std_logic lab=s24_norm_bar}
C {devices/lab_pin.sym} 1210 3710 0 1 {name=l1021 sig_type=std_logic lab=s25_norm}
C {devices/lab_pin.sym} 1210 3730 0 1 {name=l1022 sig_type=std_logic lab=s25_norm_bar}
C {devices/lab_pin.sym} 1210 3750 0 1 {name=l1023 sig_type=std_logic lab=s26_norm}
C {devices/lab_pin.sym} 1210 3770 0 1 {name=l1024 sig_type=std_logic lab=s26_norm_bar}
C {devices/lab_pin.sym} 1210 3790 0 1 {name=l1025 sig_type=std_logic lab=s27_norm}
C {devices/lab_pin.sym} 1210 3810 0 1 {name=l1026 sig_type=std_logic lab=s27_norm_bar}
C {devices/lab_pin.sym} 1210 4220 0 1 {name=l1027 sig_type=std_logic lab=s28_norm}
C {devices/lab_pin.sym} 1210 4240 0 1 {name=l1028 sig_type=std_logic lab=s28_norm_bar}
C {devices/lab_pin.sym} 1210 4260 0 1 {name=l1029 sig_type=std_logic lab=s29_norm}
C {devices/lab_pin.sym} 1210 4280 0 1 {name=l1030 sig_type=std_logic lab=s29_norm_bar}
C {devices/lab_pin.sym} 1210 4300 0 1 {name=l1031 sig_type=std_logic lab=s30_norm}
C {devices/lab_pin.sym} 1210 4320 0 1 {name=l1032 sig_type=std_logic lab=s30_norm_bar}
C {devices/lab_pin.sym} 1210 4340 0 1 {name=l1033 sig_type=std_logic lab=s31_norm}
C {devices/lab_pin.sym} 1210 4360 0 1 {name=l1034 sig_type=std_logic lab=s31_norm_bar}
C {devices/lab_pin.sym} 2550 800 0 1 {name=l1035 sig_type=std_logic lab=s32_norm}
C {devices/lab_pin.sym} 2550 820 0 1 {name=l1036 sig_type=std_logic lab=s32_norm_bar}
C {devices/lab_pin.sym} 2550 840 0 1 {name=l1037 sig_type=std_logic lab=s33_norm}
C {devices/lab_pin.sym} 2550 860 0 1 {name=l1038 sig_type=std_logic lab=s33_norm_bar}
C {devices/lab_pin.sym} 2550 880 0 1 {name=l1039 sig_type=std_logic lab=s34_norm}
C {devices/lab_pin.sym} 2550 900 0 1 {name=l1040 sig_type=std_logic lab=s34_norm_bar}
C {devices/lab_pin.sym} 2550 920 0 1 {name=l1041 sig_type=std_logic lab=s35_norm}
C {devices/lab_pin.sym} 2550 940 0 1 {name=l1042 sig_type=std_logic lab=s35_norm_bar}
C {devices/lab_pin.sym} 2550 1350 0 1 {name=l1043 sig_type=std_logic lab=s36_norm}
C {devices/lab_pin.sym} 2550 1370 0 1 {name=l1044 sig_type=std_logic lab=s36_norm_bar}
C {devices/lab_pin.sym} 2550 1390 0 1 {name=l1045 sig_type=std_logic lab=s37_norm}
C {devices/lab_pin.sym} 2550 1410 0 1 {name=l1046 sig_type=std_logic lab=s37_norm_bar}
C {devices/lab_pin.sym} 2550 1430 0 1 {name=l1047 sig_type=std_logic lab=s38_norm}
C {devices/lab_pin.sym} 2550 1450 0 1 {name=l1048 sig_type=std_logic lab=s38_norm_bar}
C {devices/lab_pin.sym} 2550 1470 0 1 {name=l1049 sig_type=std_logic lab=s39_norm}
C {devices/lab_pin.sym} 2550 1490 0 1 {name=l1050 sig_type=std_logic lab=s39_norm_bar}
C {devices/lab_pin.sym} 2550 1900 0 1 {name=l1051 sig_type=std_logic lab=s40_norm}
C {devices/lab_pin.sym} 2550 1920 0 1 {name=l1052 sig_type=std_logic lab=s40_norm_bar}
C {devices/lab_pin.sym} 2550 1940 0 1 {name=l1053 sig_type=std_logic lab=s41_norm}
C {devices/lab_pin.sym} 2550 1960 0 1 {name=l1054 sig_type=std_logic lab=s41_norm_bar}
C {devices/lab_pin.sym} 2550 1980 0 1 {name=l1055 sig_type=std_logic lab=s42_norm}
C {devices/lab_pin.sym} 2550 2000 0 1 {name=l1056 sig_type=std_logic lab=s42_norm_bar}
C {devices/lab_pin.sym} 2550 2020 0 1 {name=l1057 sig_type=std_logic lab=s43_norm}
C {devices/lab_pin.sym} 2550 2040 0 1 {name=l1058 sig_type=std_logic lab=s43_norm_bar}
C {devices/lab_pin.sym} 2550 2450 0 1 {name=l1059 sig_type=std_logic lab=s44_norm}
C {devices/lab_pin.sym} 2550 2470 0 1 {name=l1060 sig_type=std_logic lab=s44_norm_bar}
C {devices/lab_pin.sym} 2550 2490 0 1 {name=l1061 sig_type=std_logic lab=s45_norm}
C {devices/lab_pin.sym} 2550 2510 0 1 {name=l1062 sig_type=std_logic lab=s45_norm_bar}
C {devices/lab_pin.sym} 2550 2530 0 1 {name=l1063 sig_type=std_logic lab=s46_norm}
C {devices/lab_pin.sym} 2550 2550 0 1 {name=l1064 sig_type=std_logic lab=s46_norm_bar}
C {devices/lab_pin.sym} 2550 2570 0 1 {name=l1065 sig_type=std_logic lab=s47_norm}
C {devices/lab_pin.sym} 2550 2590 0 1 {name=l1066 sig_type=std_logic lab=s47_norm_bar}
C {devices/lab_pin.sym} 2550 2970 0 1 {name=l1067 sig_type=std_logic lab=s48_norm}
C {devices/lab_pin.sym} 2550 2990 0 1 {name=l1068 sig_type=std_logic lab=s48_norm_bar}
C {devices/lab_pin.sym} 2550 3010 0 1 {name=l1069 sig_type=std_logic lab=s49_norm}
C {devices/lab_pin.sym} 2550 3030 0 1 {name=l1070 sig_type=std_logic lab=s49_norm_bar}
C {devices/lab_pin.sym} 2550 3050 0 1 {name=l1071 sig_type=std_logic lab=s50_norm}
C {devices/lab_pin.sym} 2550 3070 0 1 {name=l1072 sig_type=std_logic lab=s50_norm_bar}
C {devices/lab_pin.sym} 2550 3090 0 1 {name=l1073 sig_type=std_logic lab=s51_norm}
C {devices/lab_pin.sym} 2550 3110 0 1 {name=l1074 sig_type=std_logic lab=s51_norm_bar}
C {devices/lab_pin.sym} 2550 3520 0 1 {name=l1075 sig_type=std_logic lab=s52_norm}
C {devices/lab_pin.sym} 2550 3540 0 1 {name=l1076 sig_type=std_logic lab=s52_norm_bar}
C {devices/lab_pin.sym} 2550 3560 0 1 {name=l1077 sig_type=std_logic lab=s53_norm}
C {devices/lab_pin.sym} 2550 3580 0 1 {name=l1078 sig_type=std_logic lab=s53_norm_bar}
C {devices/lab_pin.sym} 2550 3600 0 1 {name=l1079 sig_type=std_logic lab=s54_norm}
C {devices/lab_pin.sym} 2550 3620 0 1 {name=l1080 sig_type=std_logic lab=s54_norm_bar}
C {devices/lab_pin.sym} 2550 3640 0 1 {name=l1081 sig_type=std_logic lab=s55_norm}
C {devices/lab_pin.sym} 2550 3660 0 1 {name=l1082 sig_type=std_logic lab=s55_norm_bar}
C {devices/lab_pin.sym} 2550 4070 0 1 {name=l1083 sig_type=std_logic lab=s56_norm}
C {devices/lab_pin.sym} 2550 4090 0 1 {name=l1084 sig_type=std_logic lab=s56_norm_bar}
C {devices/lab_pin.sym} 2550 4110 0 1 {name=l1085 sig_type=std_logic lab=s57_norm}
C {devices/lab_pin.sym} 2550 4130 0 1 {name=l1086 sig_type=std_logic lab=s57_norm_bar}
C {devices/lab_pin.sym} 2550 4150 0 1 {name=l1087 sig_type=std_logic lab=s58_norm}
C {devices/lab_pin.sym} 2550 4170 0 1 {name=l1088 sig_type=std_logic lab=s58_norm_bar}
C {devices/lab_pin.sym} 2550 4190 0 1 {name=l1089 sig_type=std_logic lab=s59_norm}
C {devices/lab_pin.sym} 2550 4210 0 1 {name=l1090 sig_type=std_logic lab=s59_norm_bar}
C {devices/lab_pin.sym} 2550 4620 0 1 {name=l1091 sig_type=std_logic lab=s60_norm}
C {devices/lab_pin.sym} 2550 4640 0 1 {name=l1092 sig_type=std_logic lab=s60_norm_bar}
C {devices/lab_pin.sym} 2550 4660 0 1 {name=l1093 sig_type=std_logic lab=s61_norm}
C {devices/lab_pin.sym} 2550 4680 0 1 {name=l1094 sig_type=std_logic lab=s61_norm_bar}
C {devices/lab_pin.sym} 2550 4700 0 1 {name=l1095 sig_type=std_logic lab=s62_norm}
C {devices/lab_pin.sym} 2550 4720 0 1 {name=l1096 sig_type=std_logic lab=s62_norm_bar}
C {devices/lab_pin.sym} 2550 4740 0 1 {name=l1097 sig_type=std_logic lab=s63_norm}
C {devices/lab_pin.sym} 2550 4760 0 1 {name=l1098 sig_type=std_logic lab=s63_norm_bar}
C {EESPFAL_PRESENT80_R1.sym} 490 1030 0 0 {name=x30}
C {EESPFAL_PRESENT80_R1.sym} 810 1690 0 0 {name=x31}
C {EESPFAL_PRESENT80_R1.sym} 810 2250 0 0 {name=x32}
C {EESPFAL_PRESENT80_R1.sym} 810 2800 0 0 {name=x33}
C {EESPFAL_PRESENT80_R1.sym} 810 3350 0 0 {name=x34}
C {EESPFAL_PRESENT80_R1.sym} 810 3900 0 0 {name=x35}
C {EESPFAL_PRESENT80_R1.sym} 810 4450 0 0 {name=x36}
C {EESPFAL_PRESENT80_R1.sym} 2150 1030 0 0 {name=x37}
C {EESPFAL_PRESENT80_R1.sym} 2150 1580 0 0 {name=x38}
C {EESPFAL_PRESENT80_R1.sym} 2150 2130 0 0 {name=x39}
C {EESPFAL_PRESENT80_R1.sym} 2150 2680 0 0 {name=x40}
C {EESPFAL_PRESENT80_R1.sym} 2150 3200 0 0 {name=x41}
C {EESPFAL_PRESENT80_R1.sym} 2150 3750 0 0 {name=x42}
C {EESPFAL_PRESENT80_R1.sym} 2150 4300 0 0 {name=x43}
C {EESPFAL_PRESENT80_R1.sym} 2150 4850 0 0 {name=x44}
C {devices/gnd.sym} 640 960 0 0 {name=l516 lab=GND}
C {devices/capa.sym} 660 730 2 0 {name=C9
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 660 700 2 0 {name=l979 lab=GND}
C {devices/capa.sym} 690 730 2 0 {name=C10
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 690 700 2 0 {name=l980 lab=GND}
C {devices/capa.sym} 720 730 2 0 {name=C11
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 720 700 2 0 {name=l981 lab=GND}
C {devices/capa.sym} 750 730 2 0 {name=C12
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 750 700 2 0 {name=l982 lab=GND}
C {devices/capa.sym} 780 730 2 0 {name=C13
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 780 700 2 0 {name=l983 lab=GND}
C {devices/capa.sym} 810 730 2 0 {name=C14
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 810 700 2 0 {name=l984 lab=GND}
C {devices/capa.sym} 840 730 2 0 {name=C15
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 840 700 2 0 {name=l985 lab=GND}
C {devices/capa.sym} 870 730 2 0 {name=C16
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 870 700 2 0 {name=l986 lab=GND}
C {devices/lab_pin.sym} 890 800 0 1 {name=l1099 sig_type=std_logic lab=s4_norm}
C {devices/lab_pin.sym} 890 820 0 1 {name=l1100 sig_type=std_logic lab=s4_norm_bar}
C {devices/lab_pin.sym} 890 840 0 1 {name=l1101 sig_type=std_logic lab=s5_norm}
C {devices/lab_pin.sym} 890 860 0 1 {name=l1102 sig_type=std_logic lab=s5_norm_bar}
C {devices/lab_pin.sym} 890 880 0 1 {name=l1103 sig_type=std_logic lab=s6_norm}
C {devices/lab_pin.sym} 890 900 0 1 {name=l1104 sig_type=std_logic lab=s6_norm_bar}
C {devices/lab_pin.sym} 890 920 0 1 {name=l1105 sig_type=std_logic lab=s7_norm}
C {devices/lab_pin.sym} 890 940 0 1 {name=l1106 sig_type=std_logic lab=s7_norm_bar}
C {devices/gnd.sym} 3950 -10 3 0 {name=l1107 lab=GND}
C {devices/gnd.sym} 3950 10 3 0 {name=l1108 lab=GND}
C {devices/gnd.sym} 3950 30 3 0 {name=l1109 lab=GND}
C {devices/gnd.sym} 3950 50 3 0 {name=l1110 lab=GND}
C {devices/gnd.sym} 3950 70 3 0 {name=l1111 lab=GND}
C {devices/gnd.sym} 3950 90 3 0 {name=l1112 lab=GND}
C {devices/gnd.sym} 3950 110 3 0 {name=l1113 lab=GND}
C {devices/gnd.sym} 3950 130 3 0 {name=l1114 lab=GND}
C {devices/gnd.sym} 3950 150 3 0 {name=l1115 lab=GND}
C {devices/gnd.sym} 3950 170 3 0 {name=l1116 lab=GND}
C {devices/gnd.sym} 3950 190 3 0 {name=l1117 lab=GND}
C {devices/gnd.sym} 3950 210 3 0 {name=l1118 lab=GND}
C {devices/gnd.sym} 3950 230 3 0 {name=l1119 lab=GND}
C {devices/gnd.sym} 3950 250 3 0 {name=l1120 lab=GND}
C {devices/gnd.sym} 3950 270 3 0 {name=l1121 lab=GND}
C {devices/gnd.sym} 3950 290 3 0 {name=l1122 lab=GND}
C {devices/gnd.sym} 3950 310 3 0 {name=l1123 lab=GND}
C {devices/gnd.sym} 3950 330 3 0 {name=l1124 lab=GND}
C {devices/gnd.sym} 3950 350 3 0 {name=l1125 lab=GND}
C {devices/gnd.sym} 3950 370 3 0 {name=l1126 lab=GND}
C {devices/gnd.sym} 3950 390 3 0 {name=l1127 lab=GND}
C {devices/gnd.sym} 3950 410 3 0 {name=l1128 lab=GND}
C {devices/gnd.sym} 3950 430 3 0 {name=l1129 lab=GND}
C {devices/gnd.sym} 3950 450 3 0 {name=l1130 lab=GND}
C {devices/gnd.sym} 3950 470 3 0 {name=l1131 lab=GND}
C {devices/gnd.sym} 3950 490 3 0 {name=l1132 lab=GND}
C {devices/gnd.sym} 3950 510 3 0 {name=l1133 lab=GND}
C {devices/gnd.sym} 3950 530 3 0 {name=l1134 lab=GND}
C {devices/gnd.sym} 3950 550 3 0 {name=l1135 lab=GND}
C {devices/gnd.sym} 3950 570 3 0 {name=l1136 lab=GND}
C {devices/gnd.sym} 3950 590 3 0 {name=l1137 lab=GND}
C {devices/gnd.sym} 3950 610 3 0 {name=l1138 lab=GND}
C {devices/gnd.sym} 3950 630 3 0 {name=l1139 lab=GND}
C {devices/gnd.sym} 3950 650 3 0 {name=l1140 lab=GND}
C {devices/gnd.sym} 3950 670 3 0 {name=l1141 lab=GND}
C {devices/gnd.sym} 3950 690 3 0 {name=l1142 lab=GND}
C {devices/gnd.sym} 3950 710 3 0 {name=l1143 lab=GND}
C {devices/gnd.sym} 3950 730 3 0 {name=l1144 lab=GND}
C {devices/gnd.sym} 3950 750 3 0 {name=l1145 lab=GND}
C {devices/gnd.sym} 3950 770 3 0 {name=l1146 lab=GND}
C {devices/gnd.sym} 3950 790 3 0 {name=l1147 lab=GND}
C {devices/gnd.sym} 3950 810 3 0 {name=l1148 lab=GND}
C {devices/gnd.sym} 3950 830 3 0 {name=l1149 lab=GND}
C {devices/gnd.sym} 3950 850 3 0 {name=l1150 lab=GND}
C {devices/gnd.sym} 3950 870 3 0 {name=l1151 lab=GND}
C {devices/gnd.sym} 3950 890 3 0 {name=l1152 lab=GND}
C {devices/gnd.sym} 3950 910 3 0 {name=l1153 lab=GND}
C {devices/gnd.sym} 3950 930 3 0 {name=l1154 lab=GND}
C {devices/gnd.sym} 3950 950 3 0 {name=l1155 lab=GND}
C {devices/gnd.sym} 3950 970 3 0 {name=l1156 lab=GND}
C {devices/gnd.sym} 3950 990 3 0 {name=l1157 lab=GND}
C {devices/gnd.sym} 3950 1010 3 0 {name=l1158 lab=GND}
C {devices/gnd.sym} 3950 1030 3 0 {name=l1159 lab=GND}
C {devices/gnd.sym} 3950 1050 3 0 {name=l1160 lab=GND}
C {devices/gnd.sym} 3950 1070 3 0 {name=l1161 lab=GND}
C {devices/gnd.sym} 3950 1090 3 0 {name=l1162 lab=GND}
C {devices/gnd.sym} 3950 1110 3 0 {name=l1163 lab=GND}
C {devices/gnd.sym} 3950 1130 3 0 {name=l1164 lab=GND}
C {devices/gnd.sym} 3950 1150 3 0 {name=l1165 lab=GND}
C {devices/gnd.sym} 3950 1170 3 0 {name=l1166 lab=GND}
C {devices/gnd.sym} 3950 1190 3 0 {name=l1167 lab=GND}
C {devices/gnd.sym} 3950 1210 3 0 {name=l1168 lab=GND}
C {devices/gnd.sym} 3950 1230 3 0 {name=l1169 lab=GND}
C {devices/gnd.sym} 3950 1250 3 0 {name=l1170 lab=GND}
C {devices/gnd.sym} 3950 1270 3 0 {name=l1171 lab=GND}
C {devices/gnd.sym} 3950 1290 3 0 {name=l1172 lab=GND}
C {devices/gnd.sym} 3950 1310 3 0 {name=l1173 lab=GND}
C {devices/gnd.sym} 3950 1330 3 0 {name=l1174 lab=GND}
C {devices/gnd.sym} 3950 1350 3 0 {name=l1175 lab=GND}
C {devices/gnd.sym} 3950 1370 3 0 {name=l1176 lab=GND}
C {devices/gnd.sym} 3950 1390 3 0 {name=l1177 lab=GND}
C {devices/gnd.sym} 3950 1410 3 0 {name=l1178 lab=GND}
C {devices/gnd.sym} 3950 1430 3 0 {name=l1179 lab=GND}
C {devices/gnd.sym} 3950 1450 3 0 {name=l1180 lab=GND}
C {devices/gnd.sym} 3950 1470 3 0 {name=l1181 lab=GND}
C {devices/gnd.sym} 3950 1490 3 0 {name=l1182 lab=GND}
C {devices/gnd.sym} 3950 1510 3 0 {name=l1183 lab=GND}
C {devices/gnd.sym} 3950 1530 3 0 {name=l1184 lab=GND}
C {devices/gnd.sym} 3950 1550 3 0 {name=l1185 lab=GND}
C {devices/gnd.sym} 3950 1570 3 0 {name=l1186 lab=GND}
C {devices/gnd.sym} 3950 1590 3 0 {name=l1187 lab=GND}
C {devices/gnd.sym} 3950 1610 3 0 {name=l1188 lab=GND}
C {devices/gnd.sym} 3950 1630 3 0 {name=l1189 lab=GND}
C {devices/gnd.sym} 3950 1650 3 0 {name=l1190 lab=GND}
C {devices/gnd.sym} 3950 1670 3 0 {name=l1191 lab=GND}
C {devices/gnd.sym} 3950 1690 3 0 {name=l1192 lab=GND}
C {devices/gnd.sym} 3950 1710 3 0 {name=l1193 lab=GND}
C {devices/gnd.sym} 3950 1730 3 0 {name=l1194 lab=GND}
C {devices/gnd.sym} 3950 1750 3 0 {name=l1195 lab=GND}
C {devices/gnd.sym} 3950 1770 3 0 {name=l1196 lab=GND}
C {devices/gnd.sym} 3950 1790 3 0 {name=l1197 lab=GND}
C {devices/gnd.sym} 3950 1810 3 0 {name=l1198 lab=GND}
C {devices/gnd.sym} 3950 1830 3 0 {name=l1199 lab=GND}
C {devices/gnd.sym} 3950 1850 3 0 {name=l1200 lab=GND}
C {devices/gnd.sym} 3950 1870 3 0 {name=l1201 lab=GND}
C {devices/gnd.sym} 3950 1890 3 0 {name=l1202 lab=GND}
C {devices/gnd.sym} 3950 1910 3 0 {name=l1203 lab=GND}
C {devices/gnd.sym} 3950 1930 3 0 {name=l1204 lab=GND}
C {devices/gnd.sym} 3950 1950 3 0 {name=l1205 lab=GND}
C {devices/gnd.sym} 3950 1970 3 0 {name=l1206 lab=GND}
C {devices/gnd.sym} 3950 1990 3 0 {name=l1207 lab=GND}
C {devices/gnd.sym} 3950 2010 3 0 {name=l1208 lab=GND}
C {devices/gnd.sym} 3950 2030 3 0 {name=l1209 lab=GND}
C {devices/gnd.sym} 3950 2050 3 0 {name=l1210 lab=GND}
C {devices/gnd.sym} 3950 2070 3 0 {name=l1211 lab=GND}
C {devices/gnd.sym} 3950 2090 3 0 {name=l1212 lab=GND}
C {devices/gnd.sym} 3950 2110 3 0 {name=l1213 lab=GND}
C {devices/gnd.sym} 3950 2130 3 0 {name=l1214 lab=GND}
C {devices/gnd.sym} 3950 2150 3 0 {name=l1215 lab=GND}
C {devices/gnd.sym} 3950 2170 3 0 {name=l1216 lab=GND}
C {devices/gnd.sym} 3950 2190 3 0 {name=l1217 lab=GND}
C {devices/gnd.sym} 3950 2210 3 0 {name=l1218 lab=GND}
C {devices/gnd.sym} 3950 2230 3 0 {name=l1219 lab=GND}
C {devices/gnd.sym} 3950 2250 3 0 {name=l1220 lab=GND}
C {devices/gnd.sym} 3950 2270 3 0 {name=l1221 lab=GND}
C {devices/gnd.sym} 3950 2290 3 0 {name=l1222 lab=GND}
C {devices/gnd.sym} 3950 2310 3 0 {name=l1223 lab=GND}
C {devices/gnd.sym} 3950 2330 3 0 {name=l1224 lab=GND}
C {devices/gnd.sym} 3950 2350 3 0 {name=l1225 lab=GND}
C {devices/gnd.sym} 3950 2370 3 0 {name=l1226 lab=GND}
C {devices/gnd.sym} 3950 2390 3 0 {name=l1227 lab=GND}
C {devices/gnd.sym} 3950 2410 3 0 {name=l1228 lab=GND}
C {devices/gnd.sym} 3950 2430 3 0 {name=l1229 lab=GND}
C {devices/gnd.sym} 3950 2450 3 0 {name=l1230 lab=GND}
C {devices/gnd.sym} 3950 2470 3 0 {name=l1231 lab=GND}
C {devices/gnd.sym} 3950 2490 3 0 {name=l1232 lab=GND}
C {devices/gnd.sym} 3950 2510 3 0 {name=l1233 lab=GND}
C {devices/gnd.sym} 3950 2530 3 0 {name=l1234 lab=GND}
C {devices/gnd.sym} 3950 2550 3 0 {name=l1235 lab=GND}
C {devices/gnd.sym} 3950 2570 3 0 {name=l1236 lab=GND}
C {devices/gnd.sym} 3950 2590 3 0 {name=l1237 lab=GND}
C {devices/gnd.sym} 3950 2610 3 0 {name=l1238 lab=GND}
C {devices/gnd.sym} 3950 2630 3 0 {name=l1239 lab=GND}
C {devices/gnd.sym} 3950 2650 3 0 {name=l1240 lab=GND}
C {devices/gnd.sym} 3950 2670 3 0 {name=l1241 lab=GND}
C {devices/gnd.sym} 3950 2690 3 0 {name=l1242 lab=GND}
C {devices/gnd.sym} 3950 2710 3 0 {name=l1243 lab=GND}
C {devices/gnd.sym} 3950 2730 3 0 {name=l1244 lab=GND}
C {devices/gnd.sym} 3950 2750 3 0 {name=l1245 lab=GND}
C {devices/gnd.sym} 3950 2770 3 0 {name=l1246 lab=GND}
C {devices/gnd.sym} 3950 2790 3 0 {name=l1247 lab=GND}
C {devices/gnd.sym} 3950 2810 3 0 {name=l1248 lab=GND}
C {devices/gnd.sym} 3950 2830 3 0 {name=l1249 lab=GND}
C {devices/gnd.sym} 3950 2850 3 0 {name=l1250 lab=GND}
C {devices/gnd.sym} 3950 2870 3 0 {name=l1251 lab=GND}
C {devices/gnd.sym} 3950 2890 3 0 {name=l1252 lab=GND}
C {devices/gnd.sym} 3950 2910 3 0 {name=l1253 lab=GND}
C {devices/gnd.sym} 3950 2930 3 0 {name=l1254 lab=GND}
C {devices/gnd.sym} 3950 2950 3 0 {name=l1255 lab=GND}
C {devices/gnd.sym} 3950 2970 3 0 {name=l1256 lab=GND}
C {devices/gnd.sym} 3950 2990 3 0 {name=l1257 lab=GND}
C {devices/gnd.sym} 3950 3010 3 0 {name=l1258 lab=GND}
C {devices/gnd.sym} 3950 3030 3 0 {name=l1259 lab=GND}
C {devices/gnd.sym} 3950 3050 3 0 {name=l1260 lab=GND}
C {devices/gnd.sym} 3950 3070 3 0 {name=l1261 lab=GND}
C {devices/gnd.sym} 3950 3090 3 0 {name=l1262 lab=GND}
C {devices/gnd.sym} 3950 3110 3 0 {name=l1263 lab=GND}
C {devices/gnd.sym} 3950 3130 3 0 {name=l1264 lab=GND}
C {devices/gnd.sym} 3950 3150 3 0 {name=l1265 lab=GND}
C {devices/gnd.sym} 3950 3170 3 0 {name=l1266 lab=GND}
C {devices/gnd.sym} 3950 3190 3 0 {name=l1267 lab=GND}
C {devices/gnd.sym} 3950 3210 3 0 {name=l1268 lab=GND}
C {devices/gnd.sym} 3950 3230 3 0 {name=l1269 lab=GND}
C {devices/gnd.sym} 3950 3250 3 0 {name=l1270 lab=GND}
C {devices/gnd.sym} 3950 3270 3 0 {name=l1271 lab=GND}
C {devices/gnd.sym} 3950 3290 3 0 {name=l1272 lab=GND}
C {devices/gnd.sym} 3950 3310 3 0 {name=l1273 lab=GND}
C {devices/gnd.sym} 3950 3330 3 0 {name=l1274 lab=GND}
C {devices/gnd.sym} 3950 3350 3 0 {name=l1275 lab=GND}
C {devices/gnd.sym} 3950 3370 3 0 {name=l1276 lab=GND}
C {devices/gnd.sym} 3950 3390 3 0 {name=l1277 lab=GND}
C {devices/gnd.sym} 3950 3410 3 0 {name=l1278 lab=GND}
C {devices/gnd.sym} 3950 3430 3 0 {name=l1279 lab=GND}
C {devices/gnd.sym} 3950 3450 3 0 {name=l1280 lab=GND}
C {devices/gnd.sym} 3950 3470 3 0 {name=l1281 lab=GND}
C {devices/gnd.sym} 3950 3490 3 0 {name=l1282 lab=GND}
C {devices/gnd.sym} 3950 3510 3 0 {name=l1283 lab=GND}
C {devices/gnd.sym} 3950 3530 3 0 {name=l1284 lab=GND}
C {devices/gnd.sym} 3950 3550 3 0 {name=l1285 lab=GND}
C {devices/gnd.sym} 3950 3570 3 0 {name=l1286 lab=GND}
C {devices/gnd.sym} 3950 3590 3 0 {name=l1287 lab=GND}
C {devices/gnd.sym} 3950 3610 3 0 {name=l1288 lab=GND}
C {devices/gnd.sym} 3950 3630 3 0 {name=l1289 lab=GND}
C {devices/gnd.sym} 3950 3650 3 0 {name=l1290 lab=GND}
C {devices/gnd.sym} 3950 3670 3 0 {name=l1291 lab=GND}
C {devices/gnd.sym} 3950 3690 3 0 {name=l1292 lab=GND}
C {devices/gnd.sym} 3950 3710 3 0 {name=l1293 lab=GND}
C {devices/gnd.sym} 3950 3730 3 0 {name=l1294 lab=GND}
C {devices/gnd.sym} 3950 3750 3 0 {name=l1295 lab=GND}
C {devices/gnd.sym} 3950 3770 3 0 {name=l1296 lab=GND}
C {devices/gnd.sym} 3950 3790 3 0 {name=l1297 lab=GND}
C {devices/gnd.sym} 3950 3810 3 0 {name=l1298 lab=GND}
C {devices/gnd.sym} 3950 3830 3 0 {name=l1299 lab=GND}
C {devices/gnd.sym} 3950 3850 3 0 {name=l1300 lab=GND}
C {devices/gnd.sym} 3950 3870 3 0 {name=l1301 lab=GND}
C {devices/gnd.sym} 3950 3890 3 0 {name=l1302 lab=GND}
C {devices/gnd.sym} 3950 3910 3 0 {name=l1303 lab=GND}
C {devices/gnd.sym} 3950 3930 3 0 {name=l1304 lab=GND}
C {devices/gnd.sym} 3950 3950 3 0 {name=l1305 lab=GND}
C {devices/gnd.sym} 3950 3970 3 0 {name=l1306 lab=GND}
C {devices/gnd.sym} 3950 3990 3 0 {name=l1307 lab=GND}
C {devices/gnd.sym} 3950 4010 3 0 {name=l1308 lab=GND}
C {devices/gnd.sym} 3950 4030 3 0 {name=l1309 lab=GND}
C {devices/gnd.sym} 3950 4050 3 0 {name=l1310 lab=GND}
C {devices/gnd.sym} 3950 4070 3 0 {name=l1311 lab=GND}
C {devices/gnd.sym} 3950 4090 3 0 {name=l1312 lab=GND}
C {devices/gnd.sym} 3950 4110 3 0 {name=l1313 lab=GND}
C {devices/gnd.sym} 3950 4130 3 0 {name=l1314 lab=GND}
C {devices/gnd.sym} 3950 4150 3 0 {name=l1315 lab=GND}
C {devices/gnd.sym} 3950 4170 3 0 {name=l1316 lab=GND}
C {devices/gnd.sym} 3950 4190 3 0 {name=l1317 lab=GND}
C {devices/gnd.sym} 3950 4210 3 0 {name=l1318 lab=GND}
C {devices/gnd.sym} 3950 4230 3 0 {name=l1319 lab=GND}
C {devices/gnd.sym} 3950 4250 3 0 {name=l1320 lab=GND}
C {devices/gnd.sym} 3950 4270 3 0 {name=l1321 lab=GND}
C {devices/gnd.sym} 3950 4290 3 0 {name=l1322 lab=GND}
C {devices/gnd.sym} 3950 4310 3 0 {name=l1323 lab=GND}
C {devices/gnd.sym} 3950 4330 3 0 {name=l1324 lab=GND}
C {devices/gnd.sym} 3950 4350 3 0 {name=l1325 lab=GND}
C {devices/gnd.sym} 3950 4370 3 0 {name=l1326 lab=GND}
C {devices/gnd.sym} 3950 4390 3 0 {name=l1327 lab=GND}
C {devices/gnd.sym} 3950 4410 3 0 {name=l1328 lab=GND}
C {devices/gnd.sym} 3950 4430 3 0 {name=l1329 lab=GND}
C {devices/gnd.sym} 3950 4450 3 0 {name=l1330 lab=GND}
C {devices/gnd.sym} 3950 4470 3 0 {name=l1331 lab=GND}
C {devices/gnd.sym} 3950 4490 3 0 {name=l1332 lab=GND}
C {devices/gnd.sym} 3950 4510 3 0 {name=l1333 lab=GND}
C {devices/gnd.sym} 3950 4530 3 0 {name=l1334 lab=GND}
C {devices/gnd.sym} 3950 4550 3 0 {name=l1335 lab=GND}
C {devices/gnd.sym} 3950 4570 3 0 {name=l1336 lab=GND}
C {devices/gnd.sym} 3950 4590 3 0 {name=l1337 lab=GND}
C {devices/gnd.sym} 3950 4610 3 0 {name=l1338 lab=GND}
C {devices/gnd.sym} 3950 4630 3 0 {name=l1339 lab=GND}
C {devices/gnd.sym} 3950 4650 3 0 {name=l1340 lab=GND}
C {devices/gnd.sym} 3950 4670 3 0 {name=l1341 lab=GND}
C {devices/gnd.sym} 3950 4690 3 0 {name=l1342 lab=GND}
C {devices/gnd.sym} 3950 4710 3 0 {name=l1343 lab=GND}
C {devices/gnd.sym} 3950 4730 3 0 {name=l1344 lab=GND}
C {devices/gnd.sym} 3950 4750 3 0 {name=l1345 lab=GND}
C {devices/gnd.sym} 3950 4770 3 0 {name=l1346 lab=GND}
C {devices/gnd.sym} 3950 4790 3 0 {name=l1347 lab=GND}
C {devices/gnd.sym} 3950 4810 3 0 {name=l1348 lab=GND}
C {devices/gnd.sym} 3950 4830 3 0 {name=l1349 lab=GND}
C {devices/gnd.sym} 3950 4850 3 0 {name=l1350 lab=GND}
C {devices/gnd.sym} 3950 4870 3 0 {name=l1351 lab=GND}
C {devices/gnd.sym} 3950 4890 3 0 {name=l1352 lab=GND}
C {devices/gnd.sym} 3950 4910 3 0 {name=l1353 lab=GND}
C {devices/gnd.sym} 3950 4930 3 0 {name=l1354 lab=GND}
C {devices/gnd.sym} 3950 4950 3 0 {name=l1355 lab=GND}
C {devices/gnd.sym} 3950 4970 3 0 {name=l1356 lab=GND}
C {devices/gnd.sym} 3950 4990 3 0 {name=l1357 lab=GND}
C {devices/gnd.sym} 3950 5010 3 0 {name=l1358 lab=GND}
C {devices/gnd.sym} 3950 5030 3 0 {name=l1359 lab=GND}
C {devices/gnd.sym} 3950 5050 3 0 {name=l1360 lab=GND}
C {devices/gnd.sym} 3950 5070 3 0 {name=l1361 lab=GND}
C {devices/gnd.sym} 3950 5090 3 0 {name=l1362 lab=GND}
C {devices/lab_pin.sym} 3840 -10 0 0 {name=l1363 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} 3840 10 0 0 {name=l1364 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} 3840 30 0 0 {name=l1365 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} 3840 50 0 0 {name=l1366 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} 3840 70 0 0 {name=l1367 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} 3840 90 0 0 {name=l1368 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} 3840 110 0 0 {name=l1369 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} 3840 130 0 0 {name=l1370 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} 3840 150 0 0 {name=l1371 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} 3840 170 0 0 {name=l1372 sig_type=std_logic lab=x2_bar_S}
C {devices/lab_pin.sym} 3840 190 0 0 {name=l1373 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} 3840 210 0 0 {name=l1374 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} 3840 230 0 0 {name=l1375 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} 3840 250 0 0 {name=l1376 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} 3840 270 0 0 {name=l1377 sig_type=std_logic lab=k3_S}
C {devices/lab_pin.sym} 3840 290 0 0 {name=l1378 sig_type=std_logic lab=k3_bar_S}
C {devices/lab_pin.sym} 3840 310 0 0 {name=l1379 sig_type=std_logic lab=x4_S}
C {devices/lab_pin.sym} 3840 330 0 0 {name=l1380 sig_type=std_logic lab=x4_bar_S}
C {devices/lab_pin.sym} 3840 350 0 0 {name=l1381 sig_type=std_logic lab=k4_S}
C {devices/lab_pin.sym} 3840 370 0 0 {name=l1382 sig_type=std_logic lab=k4_bar_S}
C {devices/lab_pin.sym} 3840 390 0 0 {name=l1383 sig_type=std_logic lab=x5_S}
C {devices/lab_pin.sym} 3840 410 0 0 {name=l1384 sig_type=std_logic lab=x5_bar_S}
C {devices/lab_pin.sym} 3840 430 0 0 {name=l1385 sig_type=std_logic lab=k5_S}
C {devices/lab_pin.sym} 3840 450 0 0 {name=l1386 sig_type=std_logic lab=k5_bar_S}
C {devices/lab_pin.sym} 3840 470 0 0 {name=l1387 sig_type=std_logic lab=x6_S}
C {devices/lab_pin.sym} 3840 490 0 0 {name=l1388 sig_type=std_logic lab=x6_bar_S}
C {devices/lab_pin.sym} 3840 510 0 0 {name=l1389 sig_type=std_logic lab=k6_S}
C {devices/lab_pin.sym} 3840 530 0 0 {name=l1390 sig_type=std_logic lab=k6_bar_S}
C {devices/lab_pin.sym} 3840 550 0 0 {name=l1391 sig_type=std_logic lab=x7_S}
C {devices/lab_pin.sym} 3840 570 0 0 {name=l1392 sig_type=std_logic lab=x7_bar_S}
C {devices/lab_pin.sym} 3840 590 0 0 {name=l1393 sig_type=std_logic lab=k7_S}
C {devices/lab_pin.sym} 3840 610 0 0 {name=l1394 sig_type=std_logic lab=k7_bar_S}
C {devices/lab_pin.sym} 3840 630 0 0 {name=l1395 sig_type=std_logic lab=x8_S}
C {devices/lab_pin.sym} 3840 650 0 0 {name=l1396 sig_type=std_logic lab=x8_bar_S}
C {devices/lab_pin.sym} 3840 670 0 0 {name=l1397 sig_type=std_logic lab=k8_S}
C {devices/lab_pin.sym} 3840 690 0 0 {name=l1398 sig_type=std_logic lab=k8_bar_S}
C {devices/lab_pin.sym} 3840 710 0 0 {name=l1399 sig_type=std_logic lab=x9_S}
C {devices/lab_pin.sym} 3840 730 0 0 {name=l1400 sig_type=std_logic lab=x9_bar_S}
C {devices/lab_pin.sym} 3840 750 0 0 {name=l1401 sig_type=std_logic lab=k9_S}
C {devices/lab_pin.sym} 3840 770 0 0 {name=l1402 sig_type=std_logic lab=k9_bar_S}
C {devices/lab_pin.sym} 3840 790 0 0 {name=l1403 sig_type=std_logic lab=x10_S}
C {devices/lab_pin.sym} 3840 810 0 0 {name=l1404 sig_type=std_logic lab=x10_bar_S}
C {devices/lab_pin.sym} 3840 830 0 0 {name=l1405 sig_type=std_logic lab=k10_S}
C {devices/lab_pin.sym} 3840 850 0 0 {name=l1406 sig_type=std_logic lab=k10_bar_S}
C {devices/lab_pin.sym} 3840 870 0 0 {name=l1407 sig_type=std_logic lab=x11_S}
C {devices/lab_pin.sym} 3840 890 0 0 {name=l1408 sig_type=std_logic lab=x11_bar_S}
C {devices/lab_pin.sym} 3840 910 0 0 {name=l1409 sig_type=std_logic lab=k11_S}
C {devices/lab_pin.sym} 3840 930 0 0 {name=l1410 sig_type=std_logic lab=k11_bar_S}
C {devices/lab_pin.sym} 3840 950 0 0 {name=l1411 sig_type=std_logic lab=x12_S}
C {devices/lab_pin.sym} 3840 970 0 0 {name=l1412 sig_type=std_logic lab=x12_bar_S}
C {devices/lab_pin.sym} 3840 990 0 0 {name=l1413 sig_type=std_logic lab=k12_S}
C {devices/lab_pin.sym} 3840 1010 0 0 {name=l1414 sig_type=std_logic lab=k12_bar_S}
C {devices/lab_pin.sym} 3840 1030 0 0 {name=l1415 sig_type=std_logic lab=x13_S}
C {devices/lab_pin.sym} 3840 1050 0 0 {name=l1416 sig_type=std_logic lab=x13_bar_S}
C {devices/lab_pin.sym} 3840 1070 0 0 {name=l1417 sig_type=std_logic lab=k13_S}
C {devices/lab_pin.sym} 3840 1090 0 0 {name=l1418 sig_type=std_logic lab=k13_bar_S}
C {devices/lab_pin.sym} 3840 1110 0 0 {name=l1419 sig_type=std_logic lab=x14_S}
C {devices/lab_pin.sym} 3840 1130 0 0 {name=l1420 sig_type=std_logic lab=x14_bar_S}
C {devices/lab_pin.sym} 3840 1150 0 0 {name=l1421 sig_type=std_logic lab=k14_S}
C {devices/lab_pin.sym} 3840 1170 0 0 {name=l1422 sig_type=std_logic lab=k14_bar_S}
C {devices/lab_pin.sym} 3840 1190 0 0 {name=l1423 sig_type=std_logic lab=x15_S}
C {devices/lab_pin.sym} 3840 1210 0 0 {name=l1424 sig_type=std_logic lab=x15_bar_S}
C {devices/lab_pin.sym} 3840 1230 0 0 {name=l1425 sig_type=std_logic lab=k15_S}
C {devices/lab_pin.sym} 3840 1250 0 0 {name=l1426 sig_type=std_logic lab=k15_bar_S}
C {devices/lab_pin.sym} 3840 1270 0 0 {name=l1427 sig_type=std_logic lab=x16_S}
C {devices/lab_pin.sym} 3840 1290 0 0 {name=l1428 sig_type=std_logic lab=x16_bar_S}
C {devices/lab_pin.sym} 3840 1310 0 0 {name=l1429 sig_type=std_logic lab=k16_S}
C {devices/lab_pin.sym} 3840 1330 0 0 {name=l1430 sig_type=std_logic lab=k16_bar_S}
C {devices/lab_pin.sym} 3840 1350 0 0 {name=l1431 sig_type=std_logic lab=x17_S}
C {devices/lab_pin.sym} 3840 1370 0 0 {name=l1432 sig_type=std_logic lab=x17_bar_S}
C {devices/lab_pin.sym} 3840 1390 0 0 {name=l1433 sig_type=std_logic lab=k17_S}
C {devices/lab_pin.sym} 3840 1410 0 0 {name=l1434 sig_type=std_logic lab=k17_bar_S}
C {devices/lab_pin.sym} 3840 1430 0 0 {name=l1435 sig_type=std_logic lab=x18_S}
C {devices/lab_pin.sym} 3840 1450 0 0 {name=l1436 sig_type=std_logic lab=x18_bar_S}
C {devices/lab_pin.sym} 3840 1470 0 0 {name=l1437 sig_type=std_logic lab=k18_S}
C {devices/lab_pin.sym} 3840 1490 0 0 {name=l1438 sig_type=std_logic lab=k18_bar_S}
C {devices/lab_pin.sym} 3840 1510 0 0 {name=l1439 sig_type=std_logic lab=x19_S}
C {devices/lab_pin.sym} 3840 1530 0 0 {name=l1440 sig_type=std_logic lab=x19_bar_S}
C {devices/lab_pin.sym} 3840 1550 0 0 {name=l1441 sig_type=std_logic lab=k19_S}
C {devices/lab_pin.sym} 3840 1570 0 0 {name=l1442 sig_type=std_logic lab=k19_bar_S}
C {devices/lab_pin.sym} 3840 1590 0 0 {name=l1443 sig_type=std_logic lab=x20_S}
C {devices/lab_pin.sym} 3840 1610 0 0 {name=l1444 sig_type=std_logic lab=x20_bar_S}
C {devices/lab_pin.sym} 3840 1630 0 0 {name=l1445 sig_type=std_logic lab=k20_S}
C {devices/lab_pin.sym} 3840 1650 0 0 {name=l1446 sig_type=std_logic lab=k20_bar_S}
C {devices/lab_pin.sym} 3840 1670 0 0 {name=l1447 sig_type=std_logic lab=x21_S}
C {devices/lab_pin.sym} 3840 1690 0 0 {name=l1448 sig_type=std_logic lab=x21_bar_S}
C {devices/lab_pin.sym} 3840 1710 0 0 {name=l1449 sig_type=std_logic lab=k21_S}
C {devices/lab_pin.sym} 3840 1730 0 0 {name=l1450 sig_type=std_logic lab=k21_bar_S}
C {devices/lab_pin.sym} 3840 1750 0 0 {name=l1451 sig_type=std_logic lab=x22_S}
C {devices/lab_pin.sym} 3840 1770 0 0 {name=l1452 sig_type=std_logic lab=x22_bar_S}
C {devices/lab_pin.sym} 3840 1790 0 0 {name=l1453 sig_type=std_logic lab=k22_S}
C {devices/lab_pin.sym} 3840 1810 0 0 {name=l1454 sig_type=std_logic lab=k22_bar_S}
C {devices/lab_pin.sym} 3840 1830 0 0 {name=l1455 sig_type=std_logic lab=x23_S}
C {devices/lab_pin.sym} 3840 1850 0 0 {name=l1456 sig_type=std_logic lab=x23_bar_S}
C {devices/lab_pin.sym} 3840 1870 0 0 {name=l1457 sig_type=std_logic lab=k23_S}
C {devices/lab_pin.sym} 3840 1890 0 0 {name=l1458 sig_type=std_logic lab=k23_bar_S}
C {devices/lab_pin.sym} 3840 1910 0 0 {name=l1459 sig_type=std_logic lab=x24_S}
C {devices/lab_pin.sym} 3840 1930 0 0 {name=l1460 sig_type=std_logic lab=x24_bar_S}
C {devices/lab_pin.sym} 3840 1950 0 0 {name=l1461 sig_type=std_logic lab=k24_S}
C {devices/lab_pin.sym} 3840 1970 0 0 {name=l1462 sig_type=std_logic lab=k24_bar_S}
C {devices/lab_pin.sym} 3840 1990 0 0 {name=l1463 sig_type=std_logic lab=x25_S}
C {devices/lab_pin.sym} 3840 2010 0 0 {name=l1464 sig_type=std_logic lab=x25_bar_S}
C {devices/lab_pin.sym} 3840 2030 0 0 {name=l1465 sig_type=std_logic lab=k25_S}
C {devices/lab_pin.sym} 3840 2050 0 0 {name=l1466 sig_type=std_logic lab=k25_bar_S}
C {devices/lab_pin.sym} 3840 2070 0 0 {name=l1467 sig_type=std_logic lab=x26_S}
C {devices/lab_pin.sym} 3840 2090 0 0 {name=l1468 sig_type=std_logic lab=x26_bar_S}
C {devices/lab_pin.sym} 3840 2110 0 0 {name=l1469 sig_type=std_logic lab=k26_S}
C {devices/lab_pin.sym} 3840 2130 0 0 {name=l1470 sig_type=std_logic lab=k26_bar_S}
C {devices/lab_pin.sym} 3840 2150 0 0 {name=l1471 sig_type=std_logic lab=x27_S}
C {devices/lab_pin.sym} 3840 2170 0 0 {name=l1472 sig_type=std_logic lab=x27_bar_S}
C {devices/lab_pin.sym} 3840 2190 0 0 {name=l1473 sig_type=std_logic lab=k27_S}
C {devices/lab_pin.sym} 3840 2210 0 0 {name=l1474 sig_type=std_logic lab=k27_bar_S}
C {devices/lab_pin.sym} 3840 2230 0 0 {name=l1475 sig_type=std_logic lab=x28_S}
C {devices/lab_pin.sym} 3840 2250 0 0 {name=l1476 sig_type=std_logic lab=x28_bar_S}
C {devices/lab_pin.sym} 3840 2270 0 0 {name=l1477 sig_type=std_logic lab=k28_S}
C {devices/lab_pin.sym} 3840 2290 0 0 {name=l1478 sig_type=std_logic lab=k28_bar_S}
C {devices/lab_pin.sym} 3840 2310 0 0 {name=l1479 sig_type=std_logic lab=x29_S}
C {devices/lab_pin.sym} 3840 2330 0 0 {name=l1480 sig_type=std_logic lab=x29_bar_S}
C {devices/lab_pin.sym} 3840 2350 0 0 {name=l1481 sig_type=std_logic lab=k29_S}
C {devices/lab_pin.sym} 3840 2370 0 0 {name=l1482 sig_type=std_logic lab=k29_bar_S}
C {devices/lab_pin.sym} 3840 2390 0 0 {name=l1483 sig_type=std_logic lab=x30_S}
C {devices/lab_pin.sym} 3840 2410 0 0 {name=l1484 sig_type=std_logic lab=x30_bar_S}
C {devices/lab_pin.sym} 3840 2430 0 0 {name=l1485 sig_type=std_logic lab=k30_S}
C {devices/lab_pin.sym} 3840 2450 0 0 {name=l1486 sig_type=std_logic lab=k30_bar_S}
C {devices/lab_pin.sym} 3840 2470 0 0 {name=l1487 sig_type=std_logic lab=x31_S}
C {devices/lab_pin.sym} 3840 2490 0 0 {name=l1488 sig_type=std_logic lab=x31_bar_S}
C {devices/lab_pin.sym} 3840 2510 0 0 {name=l1489 sig_type=std_logic lab=k31_S}
C {devices/lab_pin.sym} 3840 2530 0 0 {name=l1490 sig_type=std_logic lab=k31_bar_S}
C {devices/lab_pin.sym} 3840 2550 0 0 {name=l1491 sig_type=std_logic lab=x32_S}
C {devices/lab_pin.sym} 3840 2570 0 0 {name=l1492 sig_type=std_logic lab=x32_bar_S}
C {devices/lab_pin.sym} 3840 2590 0 0 {name=l1493 sig_type=std_logic lab=k32_S}
C {devices/lab_pin.sym} 3840 2610 0 0 {name=l1494 sig_type=std_logic lab=k32_bar_S}
C {devices/lab_pin.sym} 3840 2630 0 0 {name=l1495 sig_type=std_logic lab=x33_S}
C {devices/lab_pin.sym} 3840 2650 0 0 {name=l1496 sig_type=std_logic lab=x33_bar_S}
C {devices/lab_pin.sym} 3840 2670 0 0 {name=l1497 sig_type=std_logic lab=k33_S}
C {devices/lab_pin.sym} 3840 2690 0 0 {name=l1498 sig_type=std_logic lab=k33_bar_S}
C {devices/lab_pin.sym} 3840 2710 0 0 {name=l1499 sig_type=std_logic lab=x34_S}
C {devices/lab_pin.sym} 3840 2730 0 0 {name=l1500 sig_type=std_logic lab=x34_bar_S}
C {devices/lab_pin.sym} 3840 2750 0 0 {name=l1501 sig_type=std_logic lab=k34_S}
C {devices/lab_pin.sym} 3840 2770 0 0 {name=l1502 sig_type=std_logic lab=k34_bar_S}
C {devices/lab_pin.sym} 3840 2790 0 0 {name=l1503 sig_type=std_logic lab=x35_S}
C {devices/lab_pin.sym} 3840 2810 0 0 {name=l1504 sig_type=std_logic lab=x35_bar_S}
C {devices/lab_pin.sym} 3840 2830 0 0 {name=l1505 sig_type=std_logic lab=k35_S}
C {devices/lab_pin.sym} 3840 2850 0 0 {name=l1506 sig_type=std_logic lab=k35_bar_S}
C {devices/lab_pin.sym} 3840 2870 0 0 {name=l1507 sig_type=std_logic lab=x36_S}
C {devices/lab_pin.sym} 3840 2890 0 0 {name=l1508 sig_type=std_logic lab=x36_bar_S}
C {devices/lab_pin.sym} 3840 2910 0 0 {name=l1509 sig_type=std_logic lab=k36_S}
C {devices/lab_pin.sym} 3840 2930 0 0 {name=l1510 sig_type=std_logic lab=k36_bar_S}
C {devices/lab_pin.sym} 3840 2950 0 0 {name=l1511 sig_type=std_logic lab=x37_S}
C {devices/lab_pin.sym} 3840 2970 0 0 {name=l1512 sig_type=std_logic lab=x37_bar_S}
C {devices/lab_pin.sym} 3840 2990 0 0 {name=l1513 sig_type=std_logic lab=k37_S}
C {devices/lab_pin.sym} 3840 3010 0 0 {name=l1514 sig_type=std_logic lab=k37_bar_S}
C {devices/lab_pin.sym} 3840 3030 0 0 {name=l1515 sig_type=std_logic lab=x38_S}
C {devices/lab_pin.sym} 3840 3050 0 0 {name=l1516 sig_type=std_logic lab=x38_bar_S}
C {devices/lab_pin.sym} 3840 3070 0 0 {name=l1517 sig_type=std_logic lab=k38_S}
C {devices/lab_pin.sym} 3840 3090 0 0 {name=l1518 sig_type=std_logic lab=k38_bar_S}
C {devices/lab_pin.sym} 3840 3110 0 0 {name=l1519 sig_type=std_logic lab=x39_S}
C {devices/lab_pin.sym} 3840 3130 0 0 {name=l1520 sig_type=std_logic lab=x39_bar_S}
C {devices/lab_pin.sym} 3840 3150 0 0 {name=l1521 sig_type=std_logic lab=k39_S}
C {devices/lab_pin.sym} 3840 3170 0 0 {name=l1522 sig_type=std_logic lab=k39_bar_S}
C {devices/lab_pin.sym} 3840 3190 0 0 {name=l1523 sig_type=std_logic lab=x40_S}
C {devices/lab_pin.sym} 3840 3210 0 0 {name=l1524 sig_type=std_logic lab=x40_bar_S}
C {devices/lab_pin.sym} 3840 3230 0 0 {name=l1525 sig_type=std_logic lab=k40_S}
C {devices/lab_pin.sym} 3840 3250 0 0 {name=l1526 sig_type=std_logic lab=k40_bar_S}
C {devices/lab_pin.sym} 3840 3270 0 0 {name=l1527 sig_type=std_logic lab=x41_S}
C {devices/lab_pin.sym} 3840 3290 0 0 {name=l1528 sig_type=std_logic lab=x41_bar_S}
C {devices/lab_pin.sym} 3840 3310 0 0 {name=l1529 sig_type=std_logic lab=k41_S}
C {devices/lab_pin.sym} 3840 3330 0 0 {name=l1530 sig_type=std_logic lab=k41_bar_S}
C {devices/lab_pin.sym} 3840 3350 0 0 {name=l1531 sig_type=std_logic lab=x42_S}
C {devices/lab_pin.sym} 3840 3370 0 0 {name=l1532 sig_type=std_logic lab=x42_bar_S}
C {devices/lab_pin.sym} 3840 3390 0 0 {name=l1533 sig_type=std_logic lab=k42_S}
C {devices/lab_pin.sym} 3840 3410 0 0 {name=l1534 sig_type=std_logic lab=k42_bar_S}
C {devices/lab_pin.sym} 3840 3430 0 0 {name=l1535 sig_type=std_logic lab=x43_S}
C {devices/lab_pin.sym} 3840 3450 0 0 {name=l1536 sig_type=std_logic lab=x43_bar_S}
C {devices/lab_pin.sym} 3840 3470 0 0 {name=l1537 sig_type=std_logic lab=k43_S}
C {devices/lab_pin.sym} 3840 3490 0 0 {name=l1538 sig_type=std_logic lab=k43_bar_S}
C {devices/lab_pin.sym} 3840 3510 0 0 {name=l1539 sig_type=std_logic lab=x44_S}
C {devices/lab_pin.sym} 3840 3530 0 0 {name=l1540 sig_type=std_logic lab=x44_bar_S}
C {devices/lab_pin.sym} 3840 3550 0 0 {name=l1541 sig_type=std_logic lab=k44_S}
C {devices/lab_pin.sym} 3840 3570 0 0 {name=l1542 sig_type=std_logic lab=k44_bar_S}
C {devices/lab_pin.sym} 3840 3590 0 0 {name=l1543 sig_type=std_logic lab=x45_S}
C {devices/lab_pin.sym} 3840 3610 0 0 {name=l1544 sig_type=std_logic lab=x45_bar_S}
C {devices/lab_pin.sym} 3840 3630 0 0 {name=l1545 sig_type=std_logic lab=k45_S}
C {devices/lab_pin.sym} 3840 3650 0 0 {name=l1546 sig_type=std_logic lab=k45_bar_S}
C {devices/lab_pin.sym} 3840 3670 0 0 {name=l1547 sig_type=std_logic lab=x46_S}
C {devices/lab_pin.sym} 3840 3690 0 0 {name=l1548 sig_type=std_logic lab=x46_bar_S}
C {devices/lab_pin.sym} 3840 3710 0 0 {name=l1549 sig_type=std_logic lab=k46_S}
C {devices/lab_pin.sym} 3840 3730 0 0 {name=l1550 sig_type=std_logic lab=k46_bar_S}
C {devices/lab_pin.sym} 3840 3750 0 0 {name=l1551 sig_type=std_logic lab=x47_S}
C {devices/lab_pin.sym} 3840 3770 0 0 {name=l1552 sig_type=std_logic lab=x47_bar_S}
C {devices/lab_pin.sym} 3840 3790 0 0 {name=l1553 sig_type=std_logic lab=k47_S}
C {devices/lab_pin.sym} 3840 3810 0 0 {name=l1554 sig_type=std_logic lab=k47_bar_S}
C {devices/lab_pin.sym} 3840 3830 0 0 {name=l1555 sig_type=std_logic lab=x48_S}
C {devices/lab_pin.sym} 3840 3850 0 0 {name=l1556 sig_type=std_logic lab=x48_bar_S}
C {devices/lab_pin.sym} 3840 3870 0 0 {name=l1557 sig_type=std_logic lab=k48_S}
C {devices/lab_pin.sym} 3840 3890 0 0 {name=l1558 sig_type=std_logic lab=k48_bar_S}
C {devices/lab_pin.sym} 3840 3910 0 0 {name=l1559 sig_type=std_logic lab=x49_S}
C {devices/lab_pin.sym} 3840 3930 0 0 {name=l1560 sig_type=std_logic lab=x49_bar_S}
C {devices/lab_pin.sym} 3840 3950 0 0 {name=l1561 sig_type=std_logic lab=k49_S}
C {devices/lab_pin.sym} 3840 3970 0 0 {name=l1562 sig_type=std_logic lab=k49_bar_S}
C {devices/lab_pin.sym} 3840 3990 0 0 {name=l1563 sig_type=std_logic lab=x50_S}
C {devices/lab_pin.sym} 3840 4010 0 0 {name=l1564 sig_type=std_logic lab=x50_bar_S}
C {devices/lab_pin.sym} 3840 4030 0 0 {name=l1565 sig_type=std_logic lab=k50_S}
C {devices/lab_pin.sym} 3840 4050 0 0 {name=l1566 sig_type=std_logic lab=k50_bar_S}
C {devices/lab_pin.sym} 3840 4070 0 0 {name=l1567 sig_type=std_logic lab=x51_S}
C {devices/lab_pin.sym} 3840 4090 0 0 {name=l1568 sig_type=std_logic lab=x51_bar_S}
C {devices/lab_pin.sym} 3840 4110 0 0 {name=l1569 sig_type=std_logic lab=k51_S}
C {devices/lab_pin.sym} 3840 4130 0 0 {name=l1570 sig_type=std_logic lab=k51_bar_S}
C {devices/lab_pin.sym} 3840 4150 0 0 {name=l1571 sig_type=std_logic lab=x52_S}
C {devices/lab_pin.sym} 3840 4170 0 0 {name=l1572 sig_type=std_logic lab=x52_bar_S}
C {devices/lab_pin.sym} 3840 4190 0 0 {name=l1573 sig_type=std_logic lab=k52_S}
C {devices/lab_pin.sym} 3840 4210 0 0 {name=l1574 sig_type=std_logic lab=k52_bar_S}
C {devices/lab_pin.sym} 3840 4230 0 0 {name=l1575 sig_type=std_logic lab=x53_S}
C {devices/lab_pin.sym} 3840 4250 0 0 {name=l1576 sig_type=std_logic lab=x53_bar_S}
C {devices/lab_pin.sym} 3840 4270 0 0 {name=l1577 sig_type=std_logic lab=k53_S}
C {devices/lab_pin.sym} 3840 4290 0 0 {name=l1578 sig_type=std_logic lab=k53_bar_S}
C {devices/lab_pin.sym} 3840 4310 0 0 {name=l1579 sig_type=std_logic lab=x54_S}
C {devices/lab_pin.sym} 3840 4330 0 0 {name=l1580 sig_type=std_logic lab=x54_bar_S}
C {devices/lab_pin.sym} 3840 4350 0 0 {name=l1581 sig_type=std_logic lab=k54_S}
C {devices/lab_pin.sym} 3840 4370 0 0 {name=l1582 sig_type=std_logic lab=k54_bar_S}
C {devices/lab_pin.sym} 3840 4390 0 0 {name=l1583 sig_type=std_logic lab=x55_S}
C {devices/lab_pin.sym} 3840 4410 0 0 {name=l1584 sig_type=std_logic lab=x55_bar_S}
C {devices/lab_pin.sym} 3840 4430 0 0 {name=l1585 sig_type=std_logic lab=k55_S}
C {devices/lab_pin.sym} 3840 4450 0 0 {name=l1586 sig_type=std_logic lab=k55_bar_S}
C {devices/lab_pin.sym} 3840 4470 0 0 {name=l1587 sig_type=std_logic lab=x56_S}
C {devices/lab_pin.sym} 3840 4490 0 0 {name=l1588 sig_type=std_logic lab=x56_bar_S}
C {devices/lab_pin.sym} 3840 4510 0 0 {name=l1589 sig_type=std_logic lab=k56_S}
C {devices/lab_pin.sym} 3840 4530 0 0 {name=l1590 sig_type=std_logic lab=k56_bar_S}
C {devices/lab_pin.sym} 3840 4550 0 0 {name=l1591 sig_type=std_logic lab=x57_S}
C {devices/lab_pin.sym} 3840 4570 0 0 {name=l1592 sig_type=std_logic lab=x57_bar_S}
C {devices/lab_pin.sym} 3840 4590 0 0 {name=l1593 sig_type=std_logic lab=k57_S}
C {devices/lab_pin.sym} 3840 4610 0 0 {name=l1594 sig_type=std_logic lab=k57_bar_S}
C {devices/lab_pin.sym} 3840 4630 0 0 {name=l1595 sig_type=std_logic lab=x58_S}
C {devices/lab_pin.sym} 3840 4650 0 0 {name=l1596 sig_type=std_logic lab=x58_bar_S}
C {devices/lab_pin.sym} 3840 4670 0 0 {name=l1597 sig_type=std_logic lab=k58_S}
C {devices/lab_pin.sym} 3840 4690 0 0 {name=l1598 sig_type=std_logic lab=k58_bar_S}
C {devices/lab_pin.sym} 3840 4710 0 0 {name=l1599 sig_type=std_logic lab=x59_S}
C {devices/lab_pin.sym} 3840 4730 0 0 {name=l1600 sig_type=std_logic lab=x59_bar_S}
C {devices/lab_pin.sym} 3840 4750 0 0 {name=l1601 sig_type=std_logic lab=k59_S}
C {devices/lab_pin.sym} 3840 4770 0 0 {name=l1602 sig_type=std_logic lab=k59_bar_S}
C {devices/lab_pin.sym} 3840 4790 0 0 {name=l1603 sig_type=std_logic lab=x60_S}
C {devices/lab_pin.sym} 3840 4810 0 0 {name=l1604 sig_type=std_logic lab=x60_bar_S}
C {devices/lab_pin.sym} 3840 4830 0 0 {name=l1605 sig_type=std_logic lab=k60_S}
C {devices/lab_pin.sym} 3840 4850 0 0 {name=l1606 sig_type=std_logic lab=k60_bar_S}
C {devices/lab_pin.sym} 3840 4870 0 0 {name=l1607 sig_type=std_logic lab=x61_S}
C {devices/lab_pin.sym} 3840 4890 0 0 {name=l1608 sig_type=std_logic lab=x61_bar_S}
C {devices/lab_pin.sym} 3840 4910 0 0 {name=l1609 sig_type=std_logic lab=k61_S}
C {devices/lab_pin.sym} 3840 4930 0 0 {name=l1610 sig_type=std_logic lab=k61_bar_S}
C {devices/lab_pin.sym} 3840 4950 0 0 {name=l1611 sig_type=std_logic lab=x62_S}
C {devices/lab_pin.sym} 3840 4970 0 0 {name=l1612 sig_type=std_logic lab=x62_bar_S}
C {devices/lab_pin.sym} 3840 4990 0 0 {name=l1613 sig_type=std_logic lab=k62_S}
C {devices/lab_pin.sym} 3840 5010 0 0 {name=l1614 sig_type=std_logic lab=k62_bar_S}
C {devices/lab_pin.sym} 3840 5030 0 0 {name=l1615 sig_type=std_logic lab=x63_S}
C {devices/lab_pin.sym} 3840 5050 0 0 {name=l1616 sig_type=std_logic lab=x63_bar_S}
C {devices/lab_pin.sym} 3840 5070 0 0 {name=l1617 sig_type=std_logic lab=k63_S}
C {devices/lab_pin.sym} 3840 5090 0 0 {name=l1618 sig_type=std_logic lab=k63_bar_S}
C {devices/vsource.sym} 3920 -10 3 0 {name=Vx4 value=0}
C {devices/vsource.sym} 3920 10 3 0 {name=Vx5 value=1.8}
C {devices/vsource.sym} 3920 30 3 0 {name=Vk8 value=1.8}
C {devices/vsource.sym} 3920 50 3 0 {name=Vk9 value=0}
C {devices/vsource.sym} 3920 70 3 0 {name=Vx16 value=0}
C {devices/vsource.sym} 3920 90 3 0 {name=Vx17 value=1.8}
C {devices/vsource.sym} 3920 110 3 0 {name=Vk20 value=1.8}
C {devices/vsource.sym} 3920 130 3 0 {name=Vk21 value=0}
C {devices/vsource.sym} 3920 150 3 0 {name=Vx22 value=0}
C {devices/vsource.sym} 3920 170 3 0 {name=Vx23 value=1.8}
C {devices/vsource.sym} 3920 190 3 0 {name=Vk24 value=1.8}
C {devices/vsource.sym} 3920 210 3 0 {name=Vk25 value=0}
C {devices/vsource.sym} 3920 230 3 0 {name=Vx26 value=0}
C {devices/vsource.sym} 3920 250 3 0 {name=Vx27 value=1.8}
C {devices/vsource.sym} 3920 270 3 0 {name=Vk28 value=1.8}
C {devices/vsource.sym} 3920 290 3 0 {name=Vk29 value=0}
C {devices/vsource.sym} 3920 310 3 0 {name=Vx30 value=0}
C {devices/vsource.sym} 3920 330 3 0 {name=Vx4_bar value=1.8}
C {devices/vsource.sym} 3920 350 3 0 {name=Vk31 value=1.8}
C {devices/vsource.sym} 3920 370 3 0 {name=Vk4_bar value=0}
C {devices/vsource.sym} 3920 390 3 0 {name=Vx32 value=0}
C {devices/vsource.sym} 3920 410 3 0 {name=Vx5_bar value=1.8}
C {devices/vsource.sym} 3920 430 3 0 {name=Vk33 value=1.8}
C {devices/vsource.sym} 3920 450 3 0 {name=Vk5_bar value=0}
C {devices/vsource.sym} 3920 470 3 0 {name=Vx6 value=0}
C {devices/vsource.sym} 3920 490 3 0 {name=Vx6_bar value=1.8}
C {devices/vsource.sym} 3920 510 3 0 {name=Vk34 value=1.8}
C {devices/vsource.sym} 3920 530 3 0 {name=Vk6_bar value=0}
C {devices/vsource.sym} 3920 550 3 0 {name=Vx7 value=0}
C {devices/vsource.sym} 3920 570 3 0 {name=Vx7_bar value=1.8}
C {devices/vsource.sym} 3920 590 3 0 {name=Vk35 value=1.8}
C {devices/vsource.sym} 3920 610 3 0 {name=Vk7_bar value=0}
C {devices/vsource.sym} 3920 630 3 0 {name=Vx36 value=0}
C {devices/vsource.sym} 3920 650 3 0 {name=Vx8_bar value=1.8}
C {devices/vsource.sym} 3920 670 3 0 {name=Vk37 value=1.8}
C {devices/vsource.sym} 3920 690 3 0 {name=Vk8_bar value=0}
C {devices/vsource.sym} 3920 710 3 0 {name=Vx38 value=0}
C {devices/vsource.sym} 3920 730 3 0 {name=Vx9_bar value=1.8}
C {devices/vsource.sym} 3920 750 3 0 {name=Vk39 value=1.8}
C {devices/vsource.sym} 3920 770 3 0 {name=Vk9_bar value=0}
C {devices/vsource.sym} 3920 790 3 0 {name=Vx40 value=0}
C {devices/vsource.sym} 3920 810 3 0 {name=Vx10_bar value=1.8}
C {devices/vsource.sym} 3920 830 3 0 {name=Vk10 value=1.8}
C {devices/vsource.sym} 3920 850 3 0 {name=Vk10_bar value=0}
C {devices/vsource.sym} 3920 870 3 0 {name=Vx41 value=0}
C {devices/vsource.sym} 3920 890 3 0 {name=Vx11_bar value=1.8}
C {devices/vsource.sym} 3920 910 3 0 {name=Vk11 value=1.8}
C {devices/vsource.sym} 3920 930 3 0 {name=Vk11_bar value=0}
C {devices/vsource.sym} 3920 950 3 0 {name=Vx42 value=0}
C {devices/vsource.sym} 3920 970 3 0 {name=Vx12_bar value=1.8}
C {devices/vsource.sym} 3920 990 3 0 {name=Vk12 value=1.8}
C {devices/vsource.sym} 3920 1010 3 0 {name=Vk12_bar value=0}
C {devices/vsource.sym} 3920 1030 3 0 {name=Vx43 value=0}
C {devices/vsource.sym} 3920 1050 3 0 {name=Vx13_bar value=1.8}
C {devices/vsource.sym} 3920 1070 3 0 {name=Vk13 value=1.8}
C {devices/vsource.sym} 3920 1090 3 0 {name=Vk13_bar value=0}
C {devices/vsource.sym} 3920 1110 3 0 {name=Vx44 value=0}
C {devices/vsource.sym} 3920 1130 3 0 {name=Vx14_bar value=1.8}
C {devices/vsource.sym} 3920 1150 3 0 {name=Vk14 value=1.8}
C {devices/vsource.sym} 3920 1170 3 0 {name=Vk14_bar value=0}
C {devices/vsource.sym} 3920 1190 3 0 {name=Vx45 value=0}
C {devices/vsource.sym} 3920 1210 3 0 {name=Vx15_bar value=1.8}
C {devices/vsource.sym} 3920 1230 3 0 {name=Vk15 value=1.8}
C {devices/vsource.sym} 3920 1250 3 0 {name=Vk15_bar value=0}
C {devices/vsource.sym} 3920 1270 3 0 {name=Vx46 value=0}
C {devices/vsource.sym} 3920 1290 3 0 {name=Vx16_bar value=1.8}
C {devices/vsource.sym} 3920 1310 3 0 {name=Vk47 value=1.8}
C {devices/vsource.sym} 3920 1330 3 0 {name=Vk16_bar value=0}
C {devices/vsource.sym} 3920 1350 3 0 {name=Vx48 value=0}
C {devices/vsource.sym} 3920 1370 3 0 {name=Vx17_bar value=1.8}
C {devices/vsource.sym} 3920 1390 3 0 {name=Vk49 value=1.8}
C {devices/vsource.sym} 3920 1410 3 0 {name=Vk17_bar value=0}
C {devices/vsource.sym} 3920 1430 3 0 {name=Vx18 value=0}
C {devices/vsource.sym} 3920 1450 3 0 {name=Vx18_bar value=1.8}
C {devices/vsource.sym} 3920 1470 3 0 {name=Vk50 value=1.8}
C {devices/vsource.sym} 3920 1490 3 0 {name=Vk18_bar value=0}
C {devices/vsource.sym} 3920 1510 3 0 {name=Vx19 value=0}
C {devices/vsource.sym} 3920 1530 3 0 {name=Vx19_bar value=1.8}
C {devices/vsource.sym} 3920 1550 3 0 {name=Vk51 value=1.8}
C {devices/vsource.sym} 3920 1570 3 0 {name=Vk19_bar value=0}
C {devices/vsource.sym} 3920 1590 3 0 {name=Vx20 value=0}
C {devices/vsource.sym} 3920 1610 3 0 {name=Vx20_bar value=1.8}
C {devices/vsource.sym} 3920 1630 3 0 {name=Vk52 value=1.8}
C {devices/vsource.sym} 3920 1650 3 0 {name=Vk20_bar value=0}
C {devices/vsource.sym} 3920 1670 3 0 {name=Vx21 value=0}
C {devices/vsource.sym} 3920 1690 3 0 {name=Vx21_bar value=1.8}
C {devices/vsource.sym} 3920 1710 3 0 {name=Vk53 value=1.8}
C {devices/vsource.sym} 3920 1730 3 0 {name=Vk21_bar value=0}
C {devices/vsource.sym} 3920 1750 3 0 {name=Vx54 value=0}
C {devices/vsource.sym} 3920 1770 3 0 {name=Vx22_bar value=1.8}
C {devices/vsource.sym} 3920 1790 3 0 {name=Vk22 value=1.8}
C {devices/vsource.sym} 3920 1810 3 0 {name=Vk22_bar value=0}
C {devices/vsource.sym} 3920 1830 3 0 {name=Vx55 value=0}
C {devices/vsource.sym} 3920 1850 3 0 {name=Vx23_bar value=1.8}
C {devices/vsource.sym} 3920 1870 3 0 {name=Vk23 value=1.8}
C {devices/vsource.sym} 3920 1890 3 0 {name=Vk23_bar value=0}
C {devices/vsource.sym} 3920 1910 3 0 {name=Vx24 value=0}
C {devices/vsource.sym} 3920 1930 3 0 {name=Vx24_bar value=1.8}
C {devices/vsource.sym} 3920 1950 3 0 {name=Vk56 value=1.8}
C {devices/vsource.sym} 3920 1970 3 0 {name=Vk24_bar value=0}
C {devices/vsource.sym} 3920 1990 3 0 {name=Vx25 value=0}
C {devices/vsource.sym} 3920 2010 3 0 {name=Vx25_bar value=1.8}
C {devices/vsource.sym} 3920 2030 3 0 {name=Vk57 value=1.8}
C {devices/vsource.sym} 3920 2050 3 0 {name=Vk25_bar value=0}
C {devices/vsource.sym} 3920 2070 3 0 {name=Vx58 value=0}
C {devices/vsource.sym} 3920 2090 3 0 {name=Vx26_bar value=1.8}
C {devices/vsource.sym} 3920 2110 3 0 {name=Vk26 value=1.8}
C {devices/vsource.sym} 3920 2130 3 0 {name=Vk26_bar value=0}
C {devices/vsource.sym} 3920 2150 3 0 {name=Vx59 value=0}
C {devices/vsource.sym} 3920 2170 3 0 {name=Vx27_bar value=1.8}
C {devices/vsource.sym} 3920 2190 3 0 {name=Vk27 value=1.8}
C {devices/vsource.sym} 3920 2210 3 0 {name=Vk27_bar value=0}
C {devices/vsource.sym} 3920 2230 3 0 {name=Vx28 value=0}
C {devices/vsource.sym} 3920 2250 3 0 {name=Vx28_bar value=1.8}
C {devices/vsource.sym} 3920 2270 3 0 {name=Vk60 value=1.8}
C {devices/vsource.sym} 3920 2290 3 0 {name=Vk28_bar value=0}
C {devices/vsource.sym} 3920 2310 3 0 {name=Vx29 value=0}
C {devices/vsource.sym} 3920 2330 3 0 {name=Vx29_bar value=1.8}
C {devices/vsource.sym} 3920 2350 3 0 {name=Vk61 value=1.8}
C {devices/vsource.sym} 3920 2370 3 0 {name=Vk29_bar value=0}
C {devices/vsource.sym} 3920 2390 3 0 {name=Vx62 value=0}
C {devices/vsource.sym} 3920 2410 3 0 {name=Vx30_bar value=1.8}
C {devices/vsource.sym} 3920 2430 3 0 {name=Vk30 value=1.8}
C {devices/vsource.sym} 3920 2450 3 0 {name=Vk30_bar value=0}
C {devices/vsource.sym} 3920 2470 3 0 {name=Vx31 value=0}
C {devices/vsource.sym} 3920 2490 3 0 {name=Vx31_bar value=1.8}
C {devices/vsource.sym} 3920 2510 3 0 {name=Vk63 value=1.8}
C {devices/vsource.sym} 3920 2530 3 0 {name=Vk31_bar value=0}
C {devices/vsource.sym} 3920 2550 3 0 {name=Vx64 value=0}
C {devices/vsource.sym} 3920 2570 3 0 {name=Vx32_bar value=1.8}
C {devices/vsource.sym} 3920 2590 3 0 {name=Vk32 value=1.8}
C {devices/vsource.sym} 3920 2610 3 0 {name=Vk32_bar value=0}
C {devices/vsource.sym} 3920 2630 3 0 {name=Vx33 value=0}
C {devices/vsource.sym} 3920 2650 3 0 {name=Vx33_bar value=1.8}
C {devices/vsource.sym} 3920 2670 3 0 {name=Vk65 value=1.8}
C {devices/vsource.sym} 3920 2690 3 0 {name=Vk33_bar value=0}
C {devices/vsource.sym} 3920 2710 3 0 {name=Vx34 value=0}
C {devices/vsource.sym} 3920 2730 3 0 {name=Vx34_bar value=1.8}
C {devices/vsource.sym} 3920 2750 3 0 {name=Vk66 value=1.8}
C {devices/vsource.sym} 3920 2770 3 0 {name=Vk34_bar value=0}
C {devices/vsource.sym} 3920 2790 3 0 {name=Vx35 value=0}
C {devices/vsource.sym} 3920 2810 3 0 {name=Vx35_bar value=1.8}
C {devices/vsource.sym} 3920 2830 3 0 {name=Vk67 value=1.8}
C {devices/vsource.sym} 3920 2850 3 0 {name=Vk35_bar value=0}
C {devices/vsource.sym} 3920 2870 3 0 {name=Vx68 value=0}
C {devices/vsource.sym} 3920 2890 3 0 {name=Vx36_bar value=1.8}
C {devices/vsource.sym} 3920 2910 3 0 {name=Vk36 value=1.8}
C {devices/vsource.sym} 3920 2930 3 0 {name=Vk36_bar value=0}
C {devices/vsource.sym} 3920 2950 3 0 {name=Vx37 value=0}
C {devices/vsource.sym} 3920 2970 3 0 {name=Vx37_bar value=1.8}
C {devices/vsource.sym} 3920 2990 3 0 {name=Vk69 value=1.8}
C {devices/vsource.sym} 3920 3010 3 0 {name=Vk37_bar value=0}
C {devices/vsource.sym} 3920 3030 3 0 {name=Vx70 value=0}
C {devices/vsource.sym} 3920 3050 3 0 {name=Vx38_bar value=1.8}
C {devices/vsource.sym} 3920 3070 3 0 {name=Vk38 value=1.8}
C {devices/vsource.sym} 3920 3090 3 0 {name=Vk38_bar value=0}
C {devices/vsource.sym} 3920 3110 3 0 {name=Vx39 value=0}
C {devices/vsource.sym} 3920 3130 3 0 {name=Vx39_bar value=1.8}
C {devices/vsource.sym} 3920 3150 3 0 {name=Vk71 value=1.8}
C {devices/vsource.sym} 3920 3170 3 0 {name=Vk39_bar value=0}
C {devices/vsource.sym} 3920 3190 3 0 {name=Vx72 value=0}
C {devices/vsource.sym} 3920 3210 3 0 {name=Vx40_bar value=1.8}
C {devices/vsource.sym} 3920 3230 3 0 {name=Vk40 value=1.8}
C {devices/vsource.sym} 3920 3250 3 0 {name=Vk40_bar value=0}
C {devices/vsource.sym} 3920 3270 3 0 {name=Vx73 value=0}
C {devices/vsource.sym} 3920 3290 3 0 {name=Vx41_bar value=1.8}
C {devices/vsource.sym} 3920 3310 3 0 {name=Vk41 value=1.8}
C {devices/vsource.sym} 3920 3330 3 0 {name=Vk41_bar value=0}
C {devices/vsource.sym} 3920 3350 3 0 {name=Vx74 value=0}
C {devices/vsource.sym} 3920 3370 3 0 {name=Vx42_bar value=1.8}
C {devices/vsource.sym} 3920 3390 3 0 {name=Vk42 value=1.8}
C {devices/vsource.sym} 3920 3410 3 0 {name=Vk42_bar value=0}
C {devices/vsource.sym} 3920 3430 3 0 {name=Vx75 value=0}
C {devices/vsource.sym} 3920 3450 3 0 {name=Vx43_bar value=1.8}
C {devices/vsource.sym} 3920 3470 3 0 {name=Vk43 value=1.8}
C {devices/vsource.sym} 3920 3490 3 0 {name=Vk43_bar value=0}
C {devices/vsource.sym} 3920 3510 3 0 {name=Vx76 value=0}
C {devices/vsource.sym} 3920 3530 3 0 {name=Vx44_bar value=1.8}
C {devices/vsource.sym} 3920 3550 3 0 {name=Vk44 value=1.8}
C {devices/vsource.sym} 3920 3570 3 0 {name=Vk44_bar value=0}
C {devices/vsource.sym} 3920 3590 3 0 {name=Vx77 value=0}
C {devices/vsource.sym} 3920 3610 3 0 {name=Vx45_bar value=1.8}
C {devices/vsource.sym} 3920 3630 3 0 {name=Vk45 value=1.8}
C {devices/vsource.sym} 3920 3650 3 0 {name=Vk45_bar value=0}
C {devices/vsource.sym} 3920 3670 3 0 {name=Vx78 value=0}
C {devices/vsource.sym} 3920 3690 3 0 {name=Vx46_bar value=1.8}
C {devices/vsource.sym} 3920 3710 3 0 {name=Vk46 value=1.8}
C {devices/vsource.sym} 3920 3730 3 0 {name=Vk46_bar value=0}
C {devices/vsource.sym} 3920 3750 3 0 {name=Vx47 value=0}
C {devices/vsource.sym} 3920 3770 3 0 {name=Vx47_bar value=1.8}
C {devices/vsource.sym} 3920 3790 3 0 {name=Vk79 value=1.8}
C {devices/vsource.sym} 3920 3810 3 0 {name=Vk47_bar value=0}
C {devices/vsource.sym} 3920 3830 3 0 {name=Vx80 value=0}
C {devices/vsource.sym} 3920 3850 3 0 {name=Vx48_bar value=1.8}
C {devices/vsource.sym} 3920 3870 3 0 {name=Vk48 value=1.8}
C {devices/vsource.sym} 3920 3890 3 0 {name=Vk48_bar value=0}
C {devices/vsource.sym} 3920 3910 3 0 {name=Vx49 value=0}
C {devices/vsource.sym} 3920 3930 3 0 {name=Vx49_bar value=1.8}
C {devices/vsource.sym} 3920 3950 3 0 {name=Vk81 value=1.8}
C {devices/vsource.sym} 3920 3970 3 0 {name=Vk49_bar value=0}
C {devices/vsource.sym} 3920 3990 3 0 {name=Vx50 value=0}
C {devices/vsource.sym} 3920 4010 3 0 {name=Vx50_bar value=1.8}
C {devices/vsource.sym} 3920 4030 3 0 {name=Vk82 value=1.8}
C {devices/vsource.sym} 3920 4050 3 0 {name=Vk50_bar value=0}
C {devices/vsource.sym} 3920 4070 3 0 {name=Vx51 value=0}
C {devices/vsource.sym} 3920 4090 3 0 {name=Vx51_bar value=1.8}
C {devices/vsource.sym} 3920 4110 3 0 {name=Vk83 value=1.8}
C {devices/vsource.sym} 3920 4130 3 0 {name=Vk51_bar value=0}
C {devices/vsource.sym} 3920 4150 3 0 {name=Vx52 value=0}
C {devices/vsource.sym} 3920 4170 3 0 {name=Vx52_bar value=1.8}
C {devices/vsource.sym} 3920 4190 3 0 {name=Vk84 value=1.8}
C {devices/vsource.sym} 3920 4210 3 0 {name=Vk52_bar value=0}
C {devices/vsource.sym} 3920 4230 3 0 {name=Vx53 value=0}
C {devices/vsource.sym} 3920 4250 3 0 {name=Vx53_bar value=1.8}
C {devices/vsource.sym} 3920 4270 3 0 {name=Vk85 value=1.8}
C {devices/vsource.sym} 3920 4290 3 0 {name=Vk53_bar value=0}
C {devices/vsource.sym} 3920 4310 3 0 {name=Vx86 value=0}
C {devices/vsource.sym} 3920 4330 3 0 {name=Vx54_bar value=1.8}
C {devices/vsource.sym} 3920 4350 3 0 {name=Vk54 value=1.8}
C {devices/vsource.sym} 3920 4370 3 0 {name=Vk54_bar value=0}
C {devices/vsource.sym} 3920 4390 3 0 {name=Vx87 value=0}
C {devices/vsource.sym} 3920 4410 3 0 {name=Vx55_bar value=1.8}
C {devices/vsource.sym} 3920 4430 3 0 {name=Vk55 value=1.8}
C {devices/vsource.sym} 3920 4450 3 0 {name=Vk55_bar value=0}
C {devices/vsource.sym} 3920 4470 3 0 {name=Vx56 value=0}
C {devices/vsource.sym} 3920 4490 3 0 {name=Vx56_bar value=1.8}
C {devices/vsource.sym} 3920 4510 3 0 {name=Vk88 value=1.8}
C {devices/vsource.sym} 3920 4530 3 0 {name=Vk56_bar value=0}
C {devices/vsource.sym} 3920 4550 3 0 {name=Vx57 value=0}
C {devices/vsource.sym} 3920 4570 3 0 {name=Vx57_bar value=1.8}
C {devices/vsource.sym} 3920 4590 3 0 {name=Vk89 value=1.8}
C {devices/vsource.sym} 3920 4610 3 0 {name=Vk57_bar value=0}
C {devices/vsource.sym} 3920 4630 3 0 {name=Vx90 value=0}
C {devices/vsource.sym} 3920 4650 3 0 {name=Vx58_bar value=1.8}
C {devices/vsource.sym} 3920 4670 3 0 {name=Vk58 value=1.8}
C {devices/vsource.sym} 3920 4690 3 0 {name=Vk58_bar value=0}
C {devices/vsource.sym} 3920 4710 3 0 {name=Vx91 value=0}
C {devices/vsource.sym} 3920 4730 3 0 {name=Vx59_bar value=1.8}
C {devices/vsource.sym} 3920 4750 3 0 {name=Vk59 value=1.8}
C {devices/vsource.sym} 3920 4770 3 0 {name=Vk59_bar value=0}
C {devices/vsource.sym} 3920 4790 3 0 {name=Vx60 value=0}
C {devices/vsource.sym} 3920 4810 3 0 {name=Vx60_bar value=1.8}
C {devices/vsource.sym} 3920 4830 3 0 {name=Vk92 value=1.8}
C {devices/vsource.sym} 3920 4850 3 0 {name=Vk60_bar value=0}
C {devices/vsource.sym} 3920 4870 3 0 {name=Vx61 value=0}
C {devices/vsource.sym} 3920 4890 3 0 {name=Vx61_bar value=1.8}
C {devices/vsource.sym} 3920 4910 3 0 {name=Vk93 value=1.8}
C {devices/vsource.sym} 3920 4930 3 0 {name=Vk61_bar value=0}
C {devices/vsource.sym} 3920 4950 3 0 {name=Vx94 value=0}
C {devices/vsource.sym} 3920 4970 3 0 {name=Vx62_bar value=1.8}
C {devices/vsource.sym} 3920 4990 3 0 {name=Vk62 value=1.8}
C {devices/vsource.sym} 3920 5010 3 0 {name=Vk62_bar value=0}
C {devices/vsource.sym} 3920 5030 3 0 {name=Vx63 value=0}
C {devices/vsource.sym} 3920 5050 3 0 {name=Vx63_bar value=1.8}
C {devices/vsource.sym} 3920 5070 3 0 {name=Vk95 value=1.8}
C {devices/vsource.sym} 3920 5090 3 0 {name=Vk63_bar value=0}
