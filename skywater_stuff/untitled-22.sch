v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}

C {devices/ipin.sym} 0 0 0 0 {name=p0x lab=x0}
C {devices/ipin.sym} 0 20 0 0 {name=p0x_bar lab=x0_bar}
C {devices/ipin.sym} 0 40 0 0 {name=p0k lab=k0}
C {devices/ipin.sym} 0 60 0 0 {name=p0k_bar lab=k0_bar}
C {devices/ipin.sym} 0 80 0 0 {name=p1x lab=x1}
C {devices/ipin.sym} 0 100 0 0 {name=p1x_bar lab=x1_bar}
C {devices/ipin.sym} 0 120 0 0 {name=p1k lab=k1}
C {devices/ipin.sym} 0 140 0 0 {name=p1k_bar lab=k1_bar}
C {devices/ipin.sym} 0 160 0 0 {name=p2x lab=x2}
C {devices/ipin.sym} 0 180 0 0 {name=p2x_bar lab=x2_bar}
C {devices/ipin.sym} 0 200 0 0 {name=p2k lab=k2}
C {devices/ipin.sym} 0 220 0 0 {name=p2k_bar lab=k2_bar}
C {devices/ipin.sym} 0 240 0 0 {name=p3x lab=x3}
C {devices/ipin.sym} 0 260 0 0 {name=p3x_bar lab=x3_bar}
C {devices/ipin.sym} 0 280 0 0 {name=p3k lab=k3}
C {devices/ipin.sym} 0 300 0 0 {name=p3k_bar lab=k3_bar}
C {devices/ipin.sym} 0 320 0 0 {name=p4x lab=x4}
C {devices/ipin.sym} 0 340 0 0 {name=p4x_bar lab=x4_bar}
C {devices/ipin.sym} 0 360 0 0 {name=p4k lab=k4}
C {devices/ipin.sym} 0 380 0 0 {name=p4k_bar lab=k4_bar}
C {devices/ipin.sym} 0 400 0 0 {name=p5x lab=x5}
C {devices/ipin.sym} 0 420 0 0 {name=p5x_bar lab=x5_bar}
C {devices/ipin.sym} 0 440 0 0 {name=p5k lab=k5}
C {devices/ipin.sym} 0 460 0 0 {name=p5k_bar lab=k5_bar}
C {devices/ipin.sym} 0 480 0 0 {name=p6x lab=x6}
C {devices/ipin.sym} 0 500 0 0 {name=p6x_bar lab=x6_bar}
C {devices/ipin.sym} 0 520 0 0 {name=p6k lab=k6}
C {devices/ipin.sym} 0 540 0 0 {name=p6k_bar lab=k6_bar}
C {devices/ipin.sym} 0 560 0 0 {name=p7x lab=x7}
C {devices/ipin.sym} 0 580 0 0 {name=p7x_bar lab=x7_bar}
C {devices/ipin.sym} 0 600 0 0 {name=p7k lab=k7}
C {devices/ipin.sym} 0 620 0 0 {name=p7k_bar lab=k7_bar}
C {devices/ipin.sym} 0 640 0 0 {name=p8x lab=x8}
C {devices/ipin.sym} 0 660 0 0 {name=p8x_bar lab=x8_bar}
C {devices/ipin.sym} 0 680 0 0 {name=p8k lab=k8}
C {devices/ipin.sym} 0 700 0 0 {name=p8k_bar lab=k8_bar}
C {devices/ipin.sym} 0 720 0 0 {name=p9x lab=x9}
C {devices/ipin.sym} 0 740 0 0 {name=p9x_bar lab=x9_bar}
C {devices/ipin.sym} 0 760 0 0 {name=p9k lab=k9}
C {devices/ipin.sym} 0 780 0 0 {name=p9k_bar lab=k9_bar}
C {devices/ipin.sym} 0 800 0 0 {name=p10x lab=x10}
C {devices/ipin.sym} 0 820 0 0 {name=p10x_bar lab=x10_bar}
C {devices/ipin.sym} 0 840 0 0 {name=p10k lab=k10}
C {devices/ipin.sym} 0 860 0 0 {name=p10k_bar lab=k10_bar}
C {devices/ipin.sym} 0 880 0 0 {name=p11x lab=x11}
C {devices/ipin.sym} 0 900 0 0 {name=p11x_bar lab=x11_bar}
C {devices/ipin.sym} 0 920 0 0 {name=p11k lab=k11}
C {devices/ipin.sym} 0 940 0 0 {name=p11k_bar lab=k11_bar}
C {devices/ipin.sym} 0 960 0 0 {name=p12x lab=x12}
C {devices/ipin.sym} 0 980 0 0 {name=p12x_bar lab=x12_bar}
C {devices/ipin.sym} 0 1000 0 0 {name=p12k lab=k12}
C {devices/ipin.sym} 0 1020 0 0 {name=p12k_bar lab=k12_bar}
C {devices/ipin.sym} 0 1040 0 0 {name=p13x lab=x13}
C {devices/ipin.sym} 0 1060 0 0 {name=p13x_bar lab=x13_bar}
C {devices/ipin.sym} 0 1080 0 0 {name=p13k lab=k13}
C {devices/ipin.sym} 0 1100 0 0 {name=p13k_bar lab=k13_bar}
C {devices/ipin.sym} 0 1120 0 0 {name=p14x lab=x14}
C {devices/ipin.sym} 0 1140 0 0 {name=p14x_bar lab=x14_bar}
C {devices/ipin.sym} 0 1160 0 0 {name=p14k lab=k14}
C {devices/ipin.sym} 0 1180 0 0 {name=p14k_bar lab=k14_bar}
C {devices/ipin.sym} 0 1200 0 0 {name=p15x lab=x15}
C {devices/ipin.sym} 0 1220 0 0 {name=p15x_bar lab=x15_bar}
C {devices/ipin.sym} 0 1240 0 0 {name=p15k lab=k15}
C {devices/ipin.sym} 0 1260 0 0 {name=p15k_bar lab=k15_bar}
C {devices/ipin.sym} 0 1280 0 0 {name=p16x lab=x16}
C {devices/ipin.sym} 0 1300 0 0 {name=p16x_bar lab=x16_bar}
C {devices/ipin.sym} 0 1320 0 0 {name=p16k lab=k16}
C {devices/ipin.sym} 0 1340 0 0 {name=p16k_bar lab=k16_bar}
C {devices/ipin.sym} 0 1360 0 0 {name=p17x lab=x17}
C {devices/ipin.sym} 0 1380 0 0 {name=p17x_bar lab=x17_bar}
C {devices/ipin.sym} 0 1400 0 0 {name=p17k lab=k17}
C {devices/ipin.sym} 0 1420 0 0 {name=p17k_bar lab=k17_bar}
C {devices/ipin.sym} 0 1440 0 0 {name=p18x lab=x18}
C {devices/ipin.sym} 0 1460 0 0 {name=p18x_bar lab=x18_bar}
C {devices/ipin.sym} 0 1480 0 0 {name=p18k lab=k18}
C {devices/ipin.sym} 0 1500 0 0 {name=p18k_bar lab=k18_bar}
C {devices/ipin.sym} 0 1520 0 0 {name=p19x lab=x19}
C {devices/ipin.sym} 0 1540 0 0 {name=p19x_bar lab=x19_bar}
C {devices/ipin.sym} 0 1560 0 0 {name=p19k lab=k19}
C {devices/ipin.sym} 0 1580 0 0 {name=p19k_bar lab=k19_bar}
C {devices/ipin.sym} 0 1600 0 0 {name=p20x lab=x20}
C {devices/ipin.sym} 0 1620 0 0 {name=p20x_bar lab=x20_bar}
C {devices/ipin.sym} 0 1640 0 0 {name=p20k lab=k20}
C {devices/ipin.sym} 0 1660 0 0 {name=p20k_bar lab=k20_bar}
C {devices/ipin.sym} 0 1680 0 0 {name=p21x lab=x21}
C {devices/ipin.sym} 0 1700 0 0 {name=p21x_bar lab=x21_bar}
C {devices/ipin.sym} 0 1720 0 0 {name=p21k lab=k21}
C {devices/ipin.sym} 0 1740 0 0 {name=p21k_bar lab=k21_bar}
C {devices/ipin.sym} 0 1760 0 0 {name=p22x lab=x22}
C {devices/ipin.sym} 0 1780 0 0 {name=p22x_bar lab=x22_bar}
C {devices/ipin.sym} 0 1800 0 0 {name=p22k lab=k22}
C {devices/ipin.sym} 0 1820 0 0 {name=p22k_bar lab=k22_bar}
C {devices/ipin.sym} 0 1840 0 0 {name=p23x lab=x23}
C {devices/ipin.sym} 0 1860 0 0 {name=p23x_bar lab=x23_bar}
C {devices/ipin.sym} 0 1880 0 0 {name=p23k lab=k23}
C {devices/ipin.sym} 0 1900 0 0 {name=p23k_bar lab=k23_bar}
C {devices/ipin.sym} 0 1920 0 0 {name=p24x lab=x24}
C {devices/ipin.sym} 0 1940 0 0 {name=p24x_bar lab=x24_bar}
C {devices/ipin.sym} 0 1960 0 0 {name=p24k lab=k24}
C {devices/ipin.sym} 0 1980 0 0 {name=p24k_bar lab=k24_bar}
C {devices/ipin.sym} 0 2000 0 0 {name=p25x lab=x25}
C {devices/ipin.sym} 0 2020 0 0 {name=p25x_bar lab=x25_bar}
C {devices/ipin.sym} 0 2040 0 0 {name=p25k lab=k25}
C {devices/ipin.sym} 0 2060 0 0 {name=p25k_bar lab=k25_bar}
C {devices/ipin.sym} 0 2080 0 0 {name=p26x lab=x26}
C {devices/ipin.sym} 0 2100 0 0 {name=p26x_bar lab=x26_bar}
C {devices/ipin.sym} 0 2120 0 0 {name=p26k lab=k26}
C {devices/ipin.sym} 0 2140 0 0 {name=p26k_bar lab=k26_bar}
C {devices/ipin.sym} 0 2160 0 0 {name=p27x lab=x27}
C {devices/ipin.sym} 0 2180 0 0 {name=p27x_bar lab=x27_bar}
C {devices/ipin.sym} 0 2200 0 0 {name=p27k lab=k27}
C {devices/ipin.sym} 0 2220 0 0 {name=p27k_bar lab=k27_bar}
C {devices/ipin.sym} 0 2240 0 0 {name=p28x lab=x28}
C {devices/ipin.sym} 0 2260 0 0 {name=p28x_bar lab=x28_bar}
C {devices/ipin.sym} 0 2280 0 0 {name=p28k lab=k28}
C {devices/ipin.sym} 0 2300 0 0 {name=p28k_bar lab=k28_bar}
C {devices/ipin.sym} 0 2320 0 0 {name=p29x lab=x29}
C {devices/ipin.sym} 0 2340 0 0 {name=p29x_bar lab=x29_bar}
C {devices/ipin.sym} 0 2360 0 0 {name=p29k lab=k29}
C {devices/ipin.sym} 0 2380 0 0 {name=p29k_bar lab=k29_bar}
C {devices/ipin.sym} 0 2400 0 0 {name=p30x lab=x30}
C {devices/ipin.sym} 0 2420 0 0 {name=p30x_bar lab=x30_bar}
C {devices/ipin.sym} 0 2440 0 0 {name=p30k lab=k30}
C {devices/ipin.sym} 0 2460 0 0 {name=p30k_bar lab=k30_bar}
C {devices/ipin.sym} 0 2480 0 0 {name=p31x lab=x31}
C {devices/ipin.sym} 0 2500 0 0 {name=p31x_bar lab=x31_bar}
C {devices/ipin.sym} 0 2520 0 0 {name=p31k lab=k31}
C {devices/ipin.sym} 0 2540 0 0 {name=p31k_bar lab=k31_bar}
C {devices/ipin.sym} 0 2560 0 0 {name=p32x lab=x32}
C {devices/ipin.sym} 0 2580 0 0 {name=p32x_bar lab=x32_bar}
C {devices/ipin.sym} 0 2600 0 0 {name=p32k lab=k32}
C {devices/ipin.sym} 0 2620 0 0 {name=p32k_bar lab=k32_bar}
C {devices/ipin.sym} 0 2640 0 0 {name=p33x lab=x33}
C {devices/ipin.sym} 0 2660 0 0 {name=p33x_bar lab=x33_bar}
C {devices/ipin.sym} 0 2680 0 0 {name=p33k lab=k33}
C {devices/ipin.sym} 0 2700 0 0 {name=p33k_bar lab=k33_bar}
C {devices/ipin.sym} 0 2720 0 0 {name=p34x lab=x34}
C {devices/ipin.sym} 0 2740 0 0 {name=p34x_bar lab=x34_bar}
C {devices/ipin.sym} 0 2760 0 0 {name=p34k lab=k34}
C {devices/ipin.sym} 0 2780 0 0 {name=p34k_bar lab=k34_bar}
C {devices/ipin.sym} 0 2800 0 0 {name=p35x lab=x35}
C {devices/ipin.sym} 0 2820 0 0 {name=p35x_bar lab=x35_bar}
C {devices/ipin.sym} 0 2840 0 0 {name=p35k lab=k35}
C {devices/ipin.sym} 0 2860 0 0 {name=p35k_bar lab=k35_bar}
C {devices/ipin.sym} 0 2880 0 0 {name=p36x lab=x36}
C {devices/ipin.sym} 0 2900 0 0 {name=p36x_bar lab=x36_bar}
C {devices/ipin.sym} 0 2920 0 0 {name=p36k lab=k36}
C {devices/ipin.sym} 0 2940 0 0 {name=p36k_bar lab=k36_bar}
C {devices/ipin.sym} 0 2960 0 0 {name=p37x lab=x37}
C {devices/ipin.sym} 0 2980 0 0 {name=p37x_bar lab=x37_bar}
C {devices/ipin.sym} 0 3000 0 0 {name=p37k lab=k37}
C {devices/ipin.sym} 0 3020 0 0 {name=p37k_bar lab=k37_bar}
C {devices/ipin.sym} 0 3040 0 0 {name=p38x lab=x38}
C {devices/ipin.sym} 0 3060 0 0 {name=p38x_bar lab=x38_bar}
C {devices/ipin.sym} 0 3080 0 0 {name=p38k lab=k38}
C {devices/ipin.sym} 0 3100 0 0 {name=p38k_bar lab=k38_bar}
C {devices/ipin.sym} 0 3120 0 0 {name=p39x lab=x39}
C {devices/ipin.sym} 0 3140 0 0 {name=p39x_bar lab=x39_bar}
C {devices/ipin.sym} 0 3160 0 0 {name=p39k lab=k39}
C {devices/ipin.sym} 0 3180 0 0 {name=p39k_bar lab=k39_bar}
C {devices/ipin.sym} 0 3200 0 0 {name=p40x lab=x40}
C {devices/ipin.sym} 0 3220 0 0 {name=p40x_bar lab=x40_bar}
C {devices/ipin.sym} 0 3240 0 0 {name=p40k lab=k40}
C {devices/ipin.sym} 0 3260 0 0 {name=p40k_bar lab=k40_bar}
C {devices/ipin.sym} 0 3280 0 0 {name=p41x lab=x41}
C {devices/ipin.sym} 0 3300 0 0 {name=p41x_bar lab=x41_bar}
C {devices/ipin.sym} 0 3320 0 0 {name=p41k lab=k41}
C {devices/ipin.sym} 0 3340 0 0 {name=p41k_bar lab=k41_bar}
C {devices/ipin.sym} 0 3360 0 0 {name=p42x lab=x42}
C {devices/ipin.sym} 0 3380 0 0 {name=p42x_bar lab=x42_bar}
C {devices/ipin.sym} 0 3400 0 0 {name=p42k lab=k42}
C {devices/ipin.sym} 0 3420 0 0 {name=p42k_bar lab=k42_bar}
C {devices/ipin.sym} 0 3440 0 0 {name=p43x lab=x43}
C {devices/ipin.sym} 0 3460 0 0 {name=p43x_bar lab=x43_bar}
C {devices/ipin.sym} 0 3480 0 0 {name=p43k lab=k43}
C {devices/ipin.sym} 0 3500 0 0 {name=p43k_bar lab=k43_bar}
C {devices/ipin.sym} 0 3520 0 0 {name=p44x lab=x44}
C {devices/ipin.sym} 0 3540 0 0 {name=p44x_bar lab=x44_bar}
C {devices/ipin.sym} 0 3560 0 0 {name=p44k lab=k44}
C {devices/ipin.sym} 0 3580 0 0 {name=p44k_bar lab=k44_bar}
C {devices/ipin.sym} 0 3600 0 0 {name=p45x lab=x45}
C {devices/ipin.sym} 0 3620 0 0 {name=p45x_bar lab=x45_bar}
C {devices/ipin.sym} 0 3640 0 0 {name=p45k lab=k45}
C {devices/ipin.sym} 0 3660 0 0 {name=p45k_bar lab=k45_bar}
C {devices/ipin.sym} 0 3680 0 0 {name=p46x lab=x46}
C {devices/ipin.sym} 0 3700 0 0 {name=p46x_bar lab=x46_bar}
C {devices/ipin.sym} 0 3720 0 0 {name=p46k lab=k46}
C {devices/ipin.sym} 0 3740 0 0 {name=p46k_bar lab=k46_bar}
C {devices/ipin.sym} 0 3760 0 0 {name=p47x lab=x47}
C {devices/ipin.sym} 0 3780 0 0 {name=p47x_bar lab=x47_bar}
C {devices/ipin.sym} 0 3800 0 0 {name=p47k lab=k47}
C {devices/ipin.sym} 0 3820 0 0 {name=p47k_bar lab=k47_bar}
C {devices/ipin.sym} 0 3840 0 0 {name=p48x lab=x48}
C {devices/ipin.sym} 0 3860 0 0 {name=p48x_bar lab=x48_bar}
C {devices/ipin.sym} 0 3880 0 0 {name=p48k lab=k48}
C {devices/ipin.sym} 0 3900 0 0 {name=p48k_bar lab=k48_bar}
C {devices/ipin.sym} 0 3920 0 0 {name=p49x lab=x49}
C {devices/ipin.sym} 0 3940 0 0 {name=p49x_bar lab=x49_bar}
C {devices/ipin.sym} 0 3960 0 0 {name=p49k lab=k49}
C {devices/ipin.sym} 0 3980 0 0 {name=p49k_bar lab=k49_bar}
C {devices/ipin.sym} 0 4000 0 0 {name=p50x lab=x50}
C {devices/ipin.sym} 0 4020 0 0 {name=p50x_bar lab=x50_bar}
C {devices/ipin.sym} 0 4040 0 0 {name=p50k lab=k50}
C {devices/ipin.sym} 0 4060 0 0 {name=p50k_bar lab=k50_bar}
C {devices/ipin.sym} 0 4080 0 0 {name=p51x lab=x51}
C {devices/ipin.sym} 0 4100 0 0 {name=p51x_bar lab=x51_bar}
C {devices/ipin.sym} 0 4120 0 0 {name=p51k lab=k51}
C {devices/ipin.sym} 0 4140 0 0 {name=p51k_bar lab=k51_bar}
C {devices/ipin.sym} 0 4160 0 0 {name=p52x lab=x52}
C {devices/ipin.sym} 0 4180 0 0 {name=p52x_bar lab=x52_bar}
C {devices/ipin.sym} 0 4200 0 0 {name=p52k lab=k52}
C {devices/ipin.sym} 0 4220 0 0 {name=p52k_bar lab=k52_bar}
C {devices/ipin.sym} 0 4240 0 0 {name=p53x lab=x53}
C {devices/ipin.sym} 0 4260 0 0 {name=p53x_bar lab=x53_bar}
C {devices/ipin.sym} 0 4280 0 0 {name=p53k lab=k53}
C {devices/ipin.sym} 0 4300 0 0 {name=p53k_bar lab=k53_bar}
C {devices/ipin.sym} 0 4320 0 0 {name=p54x lab=x54}
C {devices/ipin.sym} 0 4340 0 0 {name=p54x_bar lab=x54_bar}
C {devices/ipin.sym} 0 4360 0 0 {name=p54k lab=k54}
C {devices/ipin.sym} 0 4380 0 0 {name=p54k_bar lab=k54_bar}
C {devices/ipin.sym} 0 4400 0 0 {name=p55x lab=x55}
C {devices/ipin.sym} 0 4420 0 0 {name=p55x_bar lab=x55_bar}
C {devices/ipin.sym} 0 4440 0 0 {name=p55k lab=k55}
C {devices/ipin.sym} 0 4460 0 0 {name=p55k_bar lab=k55_bar}
C {devices/ipin.sym} 0 4480 0 0 {name=p56x lab=x56}
C {devices/ipin.sym} 0 4500 0 0 {name=p56x_bar lab=x56_bar}
C {devices/ipin.sym} 0 4520 0 0 {name=p56k lab=k56}
C {devices/ipin.sym} 0 4540 0 0 {name=p56k_bar lab=k56_bar}
C {devices/ipin.sym} 0 4560 0 0 {name=p57x lab=x57}
C {devices/ipin.sym} 0 4580 0 0 {name=p57x_bar lab=x57_bar}
C {devices/ipin.sym} 0 4600 0 0 {name=p57k lab=k57}
C {devices/ipin.sym} 0 4620 0 0 {name=p57k_bar lab=k57_bar}
C {devices/ipin.sym} 0 4640 0 0 {name=p58x lab=x58}
C {devices/ipin.sym} 0 4660 0 0 {name=p58x_bar lab=x58_bar}
C {devices/ipin.sym} 0 4680 0 0 {name=p58k lab=k58}
C {devices/ipin.sym} 0 4700 0 0 {name=p58k_bar lab=k58_bar}
C {devices/ipin.sym} 0 4720 0 0 {name=p59x lab=x59}
C {devices/ipin.sym} 0 4740 0 0 {name=p59x_bar lab=x59_bar}
C {devices/ipin.sym} 0 4760 0 0 {name=p59k lab=k59}
C {devices/ipin.sym} 0 4780 0 0 {name=p59k_bar lab=k59_bar}
C {devices/ipin.sym} 0 4800 0 0 {name=p60x lab=x60}
C {devices/ipin.sym} 0 4820 0 0 {name=p60x_bar lab=x60_bar}
C {devices/ipin.sym} 0 4840 0 0 {name=p60k lab=k60}
C {devices/ipin.sym} 0 4860 0 0 {name=p60k_bar lab=k60_bar}
C {devices/ipin.sym} 0 4880 0 0 {name=p61x lab=x61}
C {devices/ipin.sym} 0 4900 0 0 {name=p61x_bar lab=x61_bar}
C {devices/ipin.sym} 0 4920 0 0 {name=p61k lab=k61}
C {devices/ipin.sym} 0 4940 0 0 {name=p61k_bar lab=k61_bar}
C {devices/ipin.sym} 0 4960 0 0 {name=p62x lab=x62}
C {devices/ipin.sym} 0 4980 0 0 {name=p62x_bar lab=x62_bar}
C {devices/ipin.sym} 0 5000 0 0 {name=p62k lab=k62}
C {devices/ipin.sym} 0 5020 0 0 {name=p62k_bar lab=k62_bar}
C {devices/ipin.sym} 0 5040 0 0 {name=p63x lab=x63}
C {devices/ipin.sym} 0 5060 0 0 {name=p63x_bar lab=x63_bar}
C {devices/ipin.sym} 0 5080 0 0 {name=p63k lab=k63}
C {devices/ipin.sym} 0 5100 0 0 {name=p63k_bar lab=k63_bar}

C {devices/opin.sym} 100 0 0 0 {name=p0s lab=s0}
C {devices/opin.sym} 100 20 0 0 {name=p0s_bar lab=s0_bar}
C {devices/opin.sym} 100 40 0 0 {name=p1s lab=s1}
C {devices/opin.sym} 100 60 0 0 {name=p1s_bar lab=s1_bar}
C {devices/opin.sym} 100 80 0 0 {name=p2s lab=s2}
C {devices/opin.sym} 100 100 0 0 {name=p2s_bar lab=s2_bar}
C {devices/opin.sym} 100 120 0 0 {name=p3s lab=s3}
C {devices/opin.sym} 100 140 0 0 {name=p3s_bar lab=s3_bar}
C {devices/opin.sym} 100 160 0 0 {name=p4s lab=s4}
C {devices/opin.sym} 100 180 0 0 {name=p4s_bar lab=s4_bar}
C {devices/opin.sym} 100 200 0 0 {name=p5s lab=s5}
C {devices/opin.sym} 100 220 0 0 {name=p5s_bar lab=s5_bar}
C {devices/opin.sym} 100 240 0 0 {name=p6s lab=s6}
C {devices/opin.sym} 100 260 0 0 {name=p6s_bar lab=s6_bar}
C {devices/opin.sym} 100 280 0 0 {name=p7s lab=s7}
C {devices/opin.sym} 100 300 0 0 {name=p7s_bar lab=s7_bar}
C {devices/opin.sym} 100 320 0 0 {name=p8s lab=s8}
C {devices/opin.sym} 100 340 0 0 {name=p8s_bar lab=s8_bar}
C {devices/opin.sym} 100 360 0 0 {name=p9s lab=s9}
C {devices/opin.sym} 100 380 0 0 {name=p9s_bar lab=s9_bar}
C {devices/opin.sym} 100 400 0 0 {name=p10s lab=s10}
C {devices/opin.sym} 100 420 0 0 {name=p10s_bar lab=s10_bar}
C {devices/opin.sym} 100 440 0 0 {name=p11s lab=s11}
C {devices/opin.sym} 100 460 0 0 {name=p11s_bar lab=s11_bar}
C {devices/opin.sym} 100 480 0 0 {name=p12s lab=s12}
C {devices/opin.sym} 100 500 0 0 {name=p12s_bar lab=s12_bar}
C {devices/opin.sym} 100 520 0 0 {name=p13s lab=s13}
C {devices/opin.sym} 100 540 0 0 {name=p13s_bar lab=s13_bar}
C {devices/opin.sym} 100 560 0 0 {name=p14s lab=s14}
C {devices/opin.sym} 100 580 0 0 {name=p14s_bar lab=s14_bar}
C {devices/opin.sym} 100 600 0 0 {name=p15s lab=s15}
C {devices/opin.sym} 100 620 0 0 {name=p15s_bar lab=s15_bar}
C {devices/opin.sym} 100 640 0 0 {name=p16s lab=s16}
C {devices/opin.sym} 100 660 0 0 {name=p16s_bar lab=s16_bar}
C {devices/opin.sym} 100 680 0 0 {name=p17s lab=s17}
C {devices/opin.sym} 100 700 0 0 {name=p17s_bar lab=s17_bar}
C {devices/opin.sym} 100 720 0 0 {name=p18s lab=s18}
C {devices/opin.sym} 100 740 0 0 {name=p18s_bar lab=s18_bar}
C {devices/opin.sym} 100 760 0 0 {name=p19s lab=s19}
C {devices/opin.sym} 100 780 0 0 {name=p19s_bar lab=s19_bar}
C {devices/opin.sym} 100 800 0 0 {name=p20s lab=s20}
C {devices/opin.sym} 100 820 0 0 {name=p20s_bar lab=s20_bar}
C {devices/opin.sym} 100 840 0 0 {name=p21s lab=s21}
C {devices/opin.sym} 100 860 0 0 {name=p21s_bar lab=s21_bar}
C {devices/opin.sym} 100 880 0 0 {name=p22s lab=s22}
C {devices/opin.sym} 100 900 0 0 {name=p22s_bar lab=s22_bar}
C {devices/opin.sym} 100 920 0 0 {name=p23s lab=s23}
C {devices/opin.sym} 100 940 0 0 {name=p23s_bar lab=s23_bar}
C {devices/opin.sym} 100 960 0 0 {name=p24s lab=s24}
C {devices/opin.sym} 100 980 0 0 {name=p24s_bar lab=s24_bar}
C {devices/opin.sym} 100 1000 0 0 {name=p25s lab=s25}
C {devices/opin.sym} 100 1020 0 0 {name=p25s_bar lab=s25_bar}
C {devices/opin.sym} 100 1040 0 0 {name=p26s lab=s26}
C {devices/opin.sym} 100 1060 0 0 {name=p26s_bar lab=s26_bar}
C {devices/opin.sym} 100 1080 0 0 {name=p27s lab=s27}
C {devices/opin.sym} 100 1100 0 0 {name=p27s_bar lab=s27_bar}
C {devices/opin.sym} 100 1120 0 0 {name=p28s lab=s28}
C {devices/opin.sym} 100 1140 0 0 {name=p28s_bar lab=s28_bar}
C {devices/opin.sym} 100 1160 0 0 {name=p29s lab=s29}
C {devices/opin.sym} 100 1180 0 0 {name=p29s_bar lab=s29_bar}
C {devices/opin.sym} 100 1200 0 0 {name=p30s lab=s30}
C {devices/opin.sym} 100 1220 0 0 {name=p30s_bar lab=s30_bar}
C {devices/opin.sym} 100 1240 0 0 {name=p31s lab=s31}
C {devices/opin.sym} 100 1260 0 0 {name=p31s_bar lab=s31_bar}
C {devices/opin.sym} 100 1280 0 0 {name=p32s lab=s32}
C {devices/opin.sym} 100 1300 0 0 {name=p32s_bar lab=s32_bar}
C {devices/opin.sym} 100 1320 0 0 {name=p33s lab=s33}
C {devices/opin.sym} 100 1340 0 0 {name=p33s_bar lab=s33_bar}
C {devices/opin.sym} 100 1360 0 0 {name=p34s lab=s34}
C {devices/opin.sym} 100 1380 0 0 {name=p34s_bar lab=s34_bar}
C {devices/opin.sym} 100 1400 0 0 {name=p35s lab=s35}
C {devices/opin.sym} 100 1420 0 0 {name=p35s_bar lab=s35_bar}
C {devices/opin.sym} 100 1440 0 0 {name=p36s lab=s36}
C {devices/opin.sym} 100 1460 0 0 {name=p36s_bar lab=s36_bar}
C {devices/opin.sym} 100 1480 0 0 {name=p37s lab=s37}
C {devices/opin.sym} 100 1500 0 0 {name=p37s_bar lab=s37_bar}
C {devices/opin.sym} 100 1520 0 0 {name=p38s lab=s38}
C {devices/opin.sym} 100 1540 0 0 {name=p38s_bar lab=s38_bar}
C {devices/opin.sym} 100 1560 0 0 {name=p39s lab=s39}
C {devices/opin.sym} 100 1580 0 0 {name=p39s_bar lab=s39_bar}
C {devices/opin.sym} 100 1600 0 0 {name=p40s lab=s40}
C {devices/opin.sym} 100 1620 0 0 {name=p40s_bar lab=s40_bar}
C {devices/opin.sym} 100 1640 0 0 {name=p41s lab=s41}
C {devices/opin.sym} 100 1660 0 0 {name=p41s_bar lab=s41_bar}
C {devices/opin.sym} 100 1680 0 0 {name=p42s lab=s42}
C {devices/opin.sym} 100 1700 0 0 {name=p42s_bar lab=s42_bar}
C {devices/opin.sym} 100 1720 0 0 {name=p43s lab=s43}
C {devices/opin.sym} 100 1740 0 0 {name=p43s_bar lab=s43_bar}
C {devices/opin.sym} 100 1760 0 0 {name=p44s lab=s44}
C {devices/opin.sym} 100 1780 0 0 {name=p44s_bar lab=s44_bar}
C {devices/opin.sym} 100 1800 0 0 {name=p45s lab=s45}
C {devices/opin.sym} 100 1820 0 0 {name=p45s_bar lab=s45_bar}
C {devices/opin.sym} 100 1840 0 0 {name=p46s lab=s46}
C {devices/opin.sym} 100 1860 0 0 {name=p46s_bar lab=s46_bar}
C {devices/opin.sym} 100 1880 0 0 {name=p47s lab=s47}
C {devices/opin.sym} 100 1900 0 0 {name=p47s_bar lab=s47_bar}
C {devices/opin.sym} 100 1920 0 0 {name=p48s lab=s48}
C {devices/opin.sym} 100 1940 0 0 {name=p48s_bar lab=s48_bar}
C {devices/opin.sym} 100 1960 0 0 {name=p49s lab=s49}
C {devices/opin.sym} 100 1980 0 0 {name=p49s_bar lab=s49_bar}
C {devices/opin.sym} 100 2000 0 0 {name=p50s lab=s50}
C {devices/opin.sym} 100 2020 0 0 {name=p50s_bar lab=s50_bar}
C {devices/opin.sym} 100 2040 0 0 {name=p51s lab=s51}
C {devices/opin.sym} 100 2060 0 0 {name=p51s_bar lab=s51_bar}
C {devices/opin.sym} 100 2080 0 0 {name=p52s lab=s52}
C {devices/opin.sym} 100 2100 0 0 {name=p52s_bar lab=s52_bar}
C {devices/opin.sym} 100 2120 0 0 {name=p53s lab=s53}
C {devices/opin.sym} 100 2140 0 0 {name=p53s_bar lab=s53_bar}
C {devices/opin.sym} 100 2160 0 0 {name=p54s lab=s54}
C {devices/opin.sym} 100 2180 0 0 {name=p54s_bar lab=s54_bar}
C {devices/opin.sym} 100 2200 0 0 {name=p55s lab=s55}
C {devices/opin.sym} 100 2220 0 0 {name=p55s_bar lab=s55_bar}
C {devices/opin.sym} 100 2240 0 0 {name=p56s lab=s56}
C {devices/opin.sym} 100 2260 0 0 {name=p56s_bar lab=s56_bar}
C {devices/opin.sym} 100 2280 0 0 {name=p57s lab=s57}
C {devices/opin.sym} 100 2300 0 0 {name=p57s_bar lab=s57_bar}
C {devices/opin.sym} 100 2320 0 0 {name=p58s lab=s58}
C {devices/opin.sym} 100 2340 0 0 {name=p58s_bar lab=s58_bar}
C {devices/opin.sym} 100 2360 0 0 {name=p59s lab=s59}
C {devices/opin.sym} 100 2380 0 0 {name=p59s_bar lab=s59_bar}
C {devices/opin.sym} 100 2400 0 0 {name=p60s lab=s60}
C {devices/opin.sym} 100 2420 0 0 {name=p60s_bar lab=s60_bar}
C {devices/opin.sym} 100 2440 0 0 {name=p61s lab=s61}
C {devices/opin.sym} 100 2460 0 0 {name=p61s_bar lab=s61_bar}
C {devices/opin.sym} 100 2480 0 0 {name=p62s lab=s62}
C {devices/opin.sym} 100 2500 0 0 {name=p62s_bar lab=s62_bar}
C {devices/opin.sym} 100 2520 0 0 {name=p63s lab=s63}
C {devices/opin.sym} 100 2540 0 0 {name=p63s_bar lab=s63_bar}




