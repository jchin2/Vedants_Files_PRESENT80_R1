v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/lab_pin.sym} -920 50 0 0 {name=l1 sig_type=std_logic lab=S0_norm}
C {devices/lab_pin.sym} -920 70 0 0 {name=l1 sig_type=std_logic lab=S1_norm}
C {devices/lab_pin.sym} -920 90 0 0 {name=l1 sig_type=std_logic lab=S2_norm}
C {devices/lab_pin.sym} -920 110 0 0 {name=l1 sig_type=std_logic lab=S3_norm}
C {devices/lab_pin.sym} -920 130 0 0 {name=l1 sig_type=std_logic lab=S4_norm}
C {devices/lab_pin.sym} -920 150 0 0 {name=l1 sig_type=std_logic lab=S5_norm}
C {devices/lab_pin.sym} -920 170 0 0 {name=l1 sig_type=std_logic lab=S6_norm}
C {devices/lab_pin.sym} -920 190 0 0 {name=l1 sig_type=std_logic lab=S7_norm}
C {devices/lab_pin.sym} -920 210 0 0 {name=l1 sig_type=std_logic lab=S8_norm}
C {devices/lab_pin.sym} -920 230 0 0 {name=l1 sig_type=std_logic lab=S9_norm}
C {devices/lab_pin.sym} -920 250 0 0 {name=l1 sig_type=std_logic lab=S10_norm}
C {devices/lab_pin.sym} -920 270 0 0 {name=l1 sig_type=std_logic lab=S11_norm}
C {devices/lab_pin.sym} -920 290 0 0 {name=l1 sig_type=std_logic lab=S12_norm}
C {devices/lab_pin.sym} -920 310 0 0 {name=l1 sig_type=std_logic lab=S13_norm}
C {devices/lab_pin.sym} -920 330 0 0 {name=l1 sig_type=std_logic lab=S14_norm}
C {devices/lab_pin.sym} -920 350 0 0 {name=l1 sig_type=std_logic lab=S15_norm}
C {devices/lab_pin.sym} -920 370 0 0 {name=l1 sig_type=std_logic lab=S16_norm}
C {devices/lab_pin.sym} -920 390 0 0 {name=l1 sig_type=std_logic lab=S17_norm}
C {devices/lab_pin.sym} -920 410 0 0 {name=l1 sig_type=std_logic lab=S18_norm}
C {devices/lab_pin.sym} -920 430 0 0 {name=l1 sig_type=std_logic lab=S19_norm}
C {devices/lab_pin.sym} -920 450 0 0 {name=l1 sig_type=std_logic lab=S20_norm}
C {devices/lab_pin.sym} -920 470 0 0 {name=l1 sig_type=std_logic lab=S21_norm}
C {devices/lab_pin.sym} -920 490 0 0 {name=l1 sig_type=std_logic lab=S22_norm}
C {devices/lab_pin.sym} -920 510 0 0 {name=l1 sig_type=std_logic lab=S23_norm}
C {devices/lab_pin.sym} -920 530 0 0 {name=l1 sig_type=std_logic lab=S24_norm}
C {devices/lab_pin.sym} -920 550 0 0 {name=l1 sig_type=std_logic lab=S25_norm}
C {devices/lab_pin.sym} -920 570 0 0 {name=l1 sig_type=std_logic lab=S26_norm}
C {devices/lab_pin.sym} -920 590 0 0 {name=l1 sig_type=std_logic lab=S27_norm}
C {devices/lab_pin.sym} -920 610 0 0 {name=l1 sig_type=std_logic lab=S28_norm}
C {devices/lab_pin.sym} -920 630 0 0 {name=l1 sig_type=std_logic lab=S29_norm}
C {devices/lab_pin.sym} -920 650 0 0 {name=l1 sig_type=std_logic lab=S30_norm}
C {devices/lab_pin.sym} -920 670 0 0 {name=l1 sig_type=std_logic lab=S31_norm}
C {devices/lab_pin.sym} -920 690 0 0 {name=l1 sig_type=std_logic lab=S32_norm}
C {devices/lab_pin.sym} -920 710 0 0 {name=l1 sig_type=std_logic lab=S33_norm}
C {devices/lab_pin.sym} -920 730 0 0 {name=l1 sig_type=std_logic lab=S34_norm}
C {devices/lab_pin.sym} -920 750 0 0 {name=l1 sig_type=std_logic lab=S35_norm}
C {devices/lab_pin.sym} -920 770 0 0 {name=l1 sig_type=std_logic lab=S36_norm}
C {devices/lab_pin.sym} -920 790 0 0 {name=l1 sig_type=std_logic lab=S37_norm}
C {devices/lab_pin.sym} -920 810 0 0 {name=l1 sig_type=std_logic lab=S38_norm}
C {devices/lab_pin.sym} -920 830 0 0 {name=l1 sig_type=std_logic lab=S39_norm}
C {devices/lab_pin.sym} -920 850 0 0 {name=l1 sig_type=std_logic lab=S40_norm}
C {devices/lab_pin.sym} -920 870 0 0 {name=l1 sig_type=std_logic lab=S41_norm}
C {devices/lab_pin.sym} -920 890 0 0 {name=l1 sig_type=std_logic lab=S42_norm}
C {devices/lab_pin.sym} -920 910 0 0 {name=l1 sig_type=std_logic lab=S43_norm}
C {devices/lab_pin.sym} -920 930 0 0 {name=l1 sig_type=std_logic lab=S44_norm}
C {devices/lab_pin.sym} -920 950 0 0 {name=l1 sig_type=std_logic lab=S45_norm}
C {devices/lab_pin.sym} -920 970 0 0 {name=l1 sig_type=std_logic lab=S46_norm}
C {devices/lab_pin.sym} -920 990 0 0 {name=l1 sig_type=std_logic lab=S47_norm}
C {devices/lab_pin.sym} -920 1010 0 0 {name=l1 sig_type=std_logic lab=S48_norm}
C {devices/lab_pin.sym} -920 1030 0 0 {name=l1 sig_type=std_logic lab=S49_norm}
C {devices/lab_pin.sym} -920 1050 0 0 {name=l1 sig_type=std_logic lab=S50_norm}
C {devices/lab_pin.sym} -920 1070 0 0 {name=l1 sig_type=std_logic lab=S51_norm}
C {devices/lab_pin.sym} -920 1090 0 0 {name=l1 sig_type=std_logic lab=S52_norm}
C {devices/lab_pin.sym} -920 1110 0 0 {name=l1 sig_type=std_logic lab=S53_norm}
C {devices/lab_pin.sym} -920 1130 0 0 {name=l1 sig_type=std_logic lab=S54_norm}
C {devices/lab_pin.sym} -920 1150 0 0 {name=l1 sig_type=std_logic lab=S55_norm}
C {devices/lab_pin.sym} -920 1170 0 0 {name=l1 sig_type=std_logic lab=S56_norm}
C {devices/lab_pin.sym} -920 1190 0 0 {name=l1 sig_type=std_logic lab=S57_norm}
C {devices/lab_pin.sym} -920 1210 0 0 {name=l1 sig_type=std_logic lab=S58_norm}
C {devices/lab_pin.sym} -920 1230 0 0 {name=l1 sig_type=std_logic lab=S59_norm}
C {devices/lab_pin.sym} -920 1250 0 0 {name=l1 sig_type=std_logic lab=S60_norm}
C {devices/lab_pin.sym} -920 1270 0 0 {name=l1 sig_type=std_logic lab=S61_norm}
C {devices/lab_pin.sym} -920 1290 0 0 {name=l1 sig_type=std_logic lab=S62_norm}
C {devices/lab_pin.sym} -920 1310 0 0 {name=l1 sig_type=std_logic lab=S63_norm}
C {devices/lab_pin.sym} -1120 50 0 0 {name=l1 sig_type=std_logic lab=x0_S}
C {devices/lab_pin.sym} -1120 70 0 0 {name=l1 sig_type=std_logic lab=x0_bar_S}
C {devices/lab_pin.sym} -1120 90 0 0 {name=l1 sig_type=std_logic lab=k0_S}
C {devices/lab_pin.sym} -1120 110 0 0 {name=l1 sig_type=std_logic lab=k0_bar_S}
C {devices/lab_pin.sym} -1120 130 0 0 {name=l1 sig_type=std_logic lab=x1_S}
C {devices/lab_pin.sym} -1120 150 0 0 {name=l1 sig_type=std_logic lab=x1_bar_S}
C {devices/lab_pin.sym} -1120 170 0 0 {name=l1 sig_type=std_logic lab=k1_S}
C {devices/lab_pin.sym} -1120 190 0 0 {name=l1 sig_type=std_logic lab=k1_bar_S}
C {devices/lab_pin.sym} -1120 210 0 0 {name=l1 sig_type=std_logic lab=x2_S}
C {devices/lab_pin.sym} -1120 230 0 0 {name=l1 sig_type=std_logic lab=x2_bar_S}
C {devices/lab_pin.sym} -1120 250 0 0 {name=l1 sig_type=std_logic lab=k2_S}
C {devices/lab_pin.sym} -1120 270 0 0 {name=l1 sig_type=std_logic lab=k2_bar_S}
C {devices/lab_pin.sym} -1120 290 0 0 {name=l1 sig_type=std_logic lab=x3_S}
C {devices/lab_pin.sym} -1120 310 0 0 {name=l1 sig_type=std_logic lab=x3_bar_S}
C {devices/lab_pin.sym} -1120 330 0 0 {name=l1 sig_type=std_logic lab=k3_S}
C {devices/lab_pin.sym} -1120 350 0 0 {name=l1 sig_type=std_logic lab=k3_bar_S}
C {devices/lab_pin.sym} -1120 370 0 0 {name=l1 sig_type=std_logic lab=x4_S}
C {devices/lab_pin.sym} -1120 390 0 0 {name=l1 sig_type=std_logic lab=x4_bar_S}
C {devices/lab_pin.sym} -1120 410 0 0 {name=l1 sig_type=std_logic lab=k4_S}
C {devices/lab_pin.sym} -1120 430 0 0 {name=l1 sig_type=std_logic lab=k4_bar_S}
C {devices/lab_pin.sym} -1120 450 0 0 {name=l1 sig_type=std_logic lab=x5_S}
C {devices/lab_pin.sym} -1120 470 0 0 {name=l1 sig_type=std_logic lab=x5_bar_S}
C {devices/lab_pin.sym} -1120 490 0 0 {name=l1 sig_type=std_logic lab=k5_S}
C {devices/lab_pin.sym} -1120 510 0 0 {name=l1 sig_type=std_logic lab=k5_bar_S}
C {devices/lab_pin.sym} -1120 530 0 0 {name=l1 sig_type=std_logic lab=x6_S}
C {devices/lab_pin.sym} -1120 550 0 0 {name=l1 sig_type=std_logic lab=x6_bar_S}
C {devices/lab_pin.sym} -1120 570 0 0 {name=l1 sig_type=std_logic lab=k6_S}
C {devices/lab_pin.sym} -1120 590 0 0 {name=l1 sig_type=std_logic lab=k6_bar_S}
C {devices/lab_pin.sym} -1120 610 0 0 {name=l1 sig_type=std_logic lab=x7_S}
C {devices/lab_pin.sym} -1120 630 0 0 {name=l1 sig_type=std_logic lab=x7_bar_S}
C {devices/lab_pin.sym} -1120 650 0 0 {name=l1 sig_type=std_logic lab=k7_S}
C {devices/lab_pin.sym} -1120 670 0 0 {name=l1 sig_type=std_logic lab=k7_bar_S}
C {devices/lab_pin.sym} -1120 690 0 0 {name=l1 sig_type=std_logic lab=x8_S}
C {devices/lab_pin.sym} -1120 710 0 0 {name=l1 sig_type=std_logic lab=x8_bar_S}
C {devices/lab_pin.sym} -1120 730 0 0 {name=l1 sig_type=std_logic lab=k8_S}
C {devices/lab_pin.sym} -1120 750 0 0 {name=l1 sig_type=std_logic lab=k8_bar_S}
C {devices/lab_pin.sym} -1120 770 0 0 {name=l1 sig_type=std_logic lab=x9_S}
C {devices/lab_pin.sym} -1120 790 0 0 {name=l1 sig_type=std_logic lab=x9_bar_S}
C {devices/lab_pin.sym} -1120 810 0 0 {name=l1 sig_type=std_logic lab=k9_S}
C {devices/lab_pin.sym} -1120 830 0 0 {name=l1 sig_type=std_logic lab=k9_bar_S}
C {devices/lab_pin.sym} -1120 850 0 0 {name=l1 sig_type=std_logic lab=x10_S}
C {devices/lab_pin.sym} -1120 870 0 0 {name=l1 sig_type=std_logic lab=x10_bar_S}
C {devices/lab_pin.sym} -1120 890 0 0 {name=l1 sig_type=std_logic lab=k10_S}
C {devices/lab_pin.sym} -1120 910 0 0 {name=l1 sig_type=std_logic lab=k10_bar_S}
C {devices/lab_pin.sym} -1120 930 0 0 {name=l1 sig_type=std_logic lab=x11_S}
C {devices/lab_pin.sym} -1120 950 0 0 {name=l1 sig_type=std_logic lab=x11_bar_S}
C {devices/lab_pin.sym} -1120 970 0 0 {name=l1 sig_type=std_logic lab=k11_S}
C {devices/lab_pin.sym} -1120 990 0 0 {name=l1 sig_type=std_logic lab=k11_bar_S}
C {devices/lab_pin.sym} -1120 1010 0 0 {name=l1 sig_type=std_logic lab=x12_S}
C {devices/lab_pin.sym} -1120 1030 0 0 {name=l1 sig_type=std_logic lab=x12_bar_S}
C {devices/lab_pin.sym} -1120 1050 0 0 {name=l1 sig_type=std_logic lab=k12_S}
C {devices/lab_pin.sym} -1120 1070 0 0 {name=l1 sig_type=std_logic lab=k12_bar_S}
C {devices/lab_pin.sym} -1120 1090 0 0 {name=l1 sig_type=std_logic lab=x13_S}
C {devices/lab_pin.sym} -1120 1110 0 0 {name=l1 sig_type=std_logic lab=x13_bar_S}
C {devices/lab_pin.sym} -1120 1130 0 0 {name=l1 sig_type=std_logic lab=k13_S}
C {devices/lab_pin.sym} -1120 1150 0 0 {name=l1 sig_type=std_logic lab=k13_bar_S}
C {devices/lab_pin.sym} -1120 1170 0 0 {name=l1 sig_type=std_logic lab=x14_S}
C {devices/lab_pin.sym} -1120 1190 0 0 {name=l1 sig_type=std_logic lab=x14_bar_S}
C {devices/lab_pin.sym} -1120 1210 0 0 {name=l1 sig_type=std_logic lab=k14_S}
C {devices/lab_pin.sym} -1120 1230 0 0 {name=l1 sig_type=std_logic lab=k14_bar_S}
C {devices/lab_pin.sym} -1120 1250 0 0 {name=l1 sig_type=std_logic lab=x15_S}
C {devices/lab_pin.sym} -1120 1270 0 0 {name=l1 sig_type=std_logic lab=x15_bar_S}
C {devices/lab_pin.sym} -1120 1290 0 0 {name=l1 sig_type=std_logic lab=k15_S}
C {devices/lab_pin.sym} -1120 1310 0 0 {name=l1 sig_type=std_logic lab=k15_bar_S}
C {devices/lab_pin.sym} -1120 1330 0 0 {name=l1 sig_type=std_logic lab=x16_S}
C {devices/lab_pin.sym} -1120 1350 0 0 {name=l1 sig_type=std_logic lab=x16_bar_S}
C {devices/lab_pin.sym} -1120 1370 0 0 {name=l1 sig_type=std_logic lab=k16_S}
C {devices/lab_pin.sym} -1120 1390 0 0 {name=l1 sig_type=std_logic lab=k16_bar_S}
C {devices/lab_pin.sym} -1120 1410 0 0 {name=l1 sig_type=std_logic lab=x17_S}
C {devices/lab_pin.sym} -1120 1430 0 0 {name=l1 sig_type=std_logic lab=x17_bar_S}
C {devices/lab_pin.sym} -1120 1450 0 0 {name=l1 sig_type=std_logic lab=k17_S}
C {devices/lab_pin.sym} -1120 1470 0 0 {name=l1 sig_type=std_logic lab=k17_bar_S}
C {devices/lab_pin.sym} -1120 1490 0 0 {name=l1 sig_type=std_logic lab=x18_S}
C {devices/lab_pin.sym} -1120 1510 0 0 {name=l1 sig_type=std_logic lab=x18_bar_S}
C {devices/lab_pin.sym} -1120 1530 0 0 {name=l1 sig_type=std_logic lab=k18_S}
C {devices/lab_pin.sym} -1120 1550 0 0 {name=l1 sig_type=std_logic lab=k18_bar_S}
C {devices/lab_pin.sym} -1120 1570 0 0 {name=l1 sig_type=std_logic lab=x19_S}
C {devices/lab_pin.sym} -1120 1590 0 0 {name=l1 sig_type=std_logic lab=x19_bar_S}
C {devices/lab_pin.sym} -1120 1610 0 0 {name=l1 sig_type=std_logic lab=k19_S}
C {devices/lab_pin.sym} -1120 1630 0 0 {name=l1 sig_type=std_logic lab=k19_bar_S}
C {devices/lab_pin.sym} -1120 1650 0 0 {name=l1 sig_type=std_logic lab=x20_S}
C {devices/lab_pin.sym} -1120 1670 0 0 {name=l1 sig_type=std_logic lab=x20_bar_S}
C {devices/lab_pin.sym} -1120 1690 0 0 {name=l1 sig_type=std_logic lab=k20_S}
C {devices/lab_pin.sym} -1120 1710 0 0 {name=l1 sig_type=std_logic lab=k20_bar_S}
C {devices/lab_pin.sym} -1120 1730 0 0 {name=l1 sig_type=std_logic lab=x21_S}
C {devices/lab_pin.sym} -1120 1750 0 0 {name=l1 sig_type=std_logic lab=x21_bar_S}
C {devices/lab_pin.sym} -1120 1770 0 0 {name=l1 sig_type=std_logic lab=k21_S}
C {devices/lab_pin.sym} -1120 1790 0 0 {name=l1 sig_type=std_logic lab=k21_bar_S}
C {devices/lab_pin.sym} -1120 1810 0 0 {name=l1 sig_type=std_logic lab=x22_S}
C {devices/lab_pin.sym} -1120 1830 0 0 {name=l1 sig_type=std_logic lab=x22_bar_S}
C {devices/lab_pin.sym} -1120 1850 0 0 {name=l1 sig_type=std_logic lab=k22_S}
C {devices/lab_pin.sym} -1120 1870 0 0 {name=l1 sig_type=std_logic lab=k22_bar_S}
C {devices/lab_pin.sym} -1120 1890 0 0 {name=l1 sig_type=std_logic lab=x23_S}
C {devices/lab_pin.sym} -1120 1910 0 0 {name=l1 sig_type=std_logic lab=x23_bar_S}
C {devices/lab_pin.sym} -1120 1930 0 0 {name=l1 sig_type=std_logic lab=k23_S}
C {devices/lab_pin.sym} -1120 1950 0 0 {name=l1 sig_type=std_logic lab=k23_bar_S}
C {devices/lab_pin.sym} -1120 1970 0 0 {name=l1 sig_type=std_logic lab=x24_S}
C {devices/lab_pin.sym} -1120 1990 0 0 {name=l1 sig_type=std_logic lab=x24_bar_S}
C {devices/lab_pin.sym} -1120 2010 0 0 {name=l1 sig_type=std_logic lab=k24_S}
C {devices/lab_pin.sym} -1120 2030 0 0 {name=l1 sig_type=std_logic lab=k24_bar_S}
C {devices/lab_pin.sym} -1120 2050 0 0 {name=l1 sig_type=std_logic lab=x25_S}
C {devices/lab_pin.sym} -1120 2070 0 0 {name=l1 sig_type=std_logic lab=x25_bar_S}
C {devices/lab_pin.sym} -1120 2090 0 0 {name=l1 sig_type=std_logic lab=k25_S}
C {devices/lab_pin.sym} -1120 2110 0 0 {name=l1 sig_type=std_logic lab=k25_bar_S}
C {devices/lab_pin.sym} -1120 2130 0 0 {name=l1 sig_type=std_logic lab=x26_S}
C {devices/lab_pin.sym} -1120 2150 0 0 {name=l1 sig_type=std_logic lab=x26_bar_S}
C {devices/lab_pin.sym} -1120 2170 0 0 {name=l1 sig_type=std_logic lab=k26_S}
C {devices/lab_pin.sym} -1120 2190 0 0 {name=l1 sig_type=std_logic lab=k26_bar_S}
C {devices/lab_pin.sym} -1120 2210 0 0 {name=l1 sig_type=std_logic lab=x27_S}
C {devices/lab_pin.sym} -1120 2230 0 0 {name=l1 sig_type=std_logic lab=x27_bar_S}
C {devices/lab_pin.sym} -1120 2250 0 0 {name=l1 sig_type=std_logic lab=k27_S}
C {devices/lab_pin.sym} -1120 2270 0 0 {name=l1 sig_type=std_logic lab=k27_bar_S}
C {devices/lab_pin.sym} -1120 2290 0 0 {name=l1 sig_type=std_logic lab=x28_S}
C {devices/lab_pin.sym} -1120 2310 0 0 {name=l1 sig_type=std_logic lab=x28_bar_S}
C {devices/lab_pin.sym} -1120 2330 0 0 {name=l1 sig_type=std_logic lab=k28_S}
C {devices/lab_pin.sym} -1120 2350 0 0 {name=l1 sig_type=std_logic lab=k28_bar_S}
C {devices/lab_pin.sym} -1120 2370 0 0 {name=l1 sig_type=std_logic lab=x29_S}
C {devices/lab_pin.sym} -1120 2390 0 0 {name=l1 sig_type=std_logic lab=x29_bar_S}
C {devices/lab_pin.sym} -1120 2410 0 0 {name=l1 sig_type=std_logic lab=k29_S}
C {devices/lab_pin.sym} -1120 2430 0 0 {name=l1 sig_type=std_logic lab=k29_bar_S}
C {devices/lab_pin.sym} -1120 2450 0 0 {name=l1 sig_type=std_logic lab=x30_S}
C {devices/lab_pin.sym} -1120 2470 0 0 {name=l1 sig_type=std_logic lab=x30_bar_S}
C {devices/lab_pin.sym} -1120 2490 0 0 {name=l1 sig_type=std_logic lab=k30_S}
C {devices/lab_pin.sym} -1120 2510 0 0 {name=l1 sig_type=std_logic lab=k30_bar_S}
C {devices/lab_pin.sym} -1120 2530 0 0 {name=l1 sig_type=std_logic lab=x31_S}
C {devices/lab_pin.sym} -1120 2550 0 0 {name=l1 sig_type=std_logic lab=x31_bar_S}
C {devices/lab_pin.sym} -1120 2570 0 0 {name=l1 sig_type=std_logic lab=k31_S}
C {devices/lab_pin.sym} -1120 2590 0 0 {name=l1 sig_type=std_logic lab=k31_bar_S}
C {devices/lab_pin.sym} -1120 2610 0 0 {name=l1 sig_type=std_logic lab=x32_S}
C {devices/lab_pin.sym} -1120 2630 0 0 {name=l1 sig_type=std_logic lab=x32_bar_S}
C {devices/lab_pin.sym} -1120 2650 0 0 {name=l1 sig_type=std_logic lab=k32_S}
C {devices/lab_pin.sym} -1120 2670 0 0 {name=l1 sig_type=std_logic lab=k32_bar_S}
C {devices/lab_pin.sym} -1120 2690 0 0 {name=l1 sig_type=std_logic lab=x33_S}
C {devices/lab_pin.sym} -1120 2710 0 0 {name=l1 sig_type=std_logic lab=x33_bar_S}
C {devices/lab_pin.sym} -1120 2730 0 0 {name=l1 sig_type=std_logic lab=k33_S}
C {devices/lab_pin.sym} -1120 2750 0 0 {name=l1 sig_type=std_logic lab=k33_bar_S}
C {devices/lab_pin.sym} -1120 2770 0 0 {name=l1 sig_type=std_logic lab=x34_S}
C {devices/lab_pin.sym} -1120 2790 0 0 {name=l1 sig_type=std_logic lab=x34_bar_S}
C {devices/lab_pin.sym} -1120 2810 0 0 {name=l1 sig_type=std_logic lab=k34_S}
C {devices/lab_pin.sym} -1120 2830 0 0 {name=l1 sig_type=std_logic lab=k34_bar_S}
C {devices/lab_pin.sym} -1120 2850 0 0 {name=l1 sig_type=std_logic lab=x35_S}
C {devices/lab_pin.sym} -1120 2870 0 0 {name=l1 sig_type=std_logic lab=x35_bar_S}
C {devices/lab_pin.sym} -1120 2890 0 0 {name=l1 sig_type=std_logic lab=k35_S}
C {devices/lab_pin.sym} -1120 2910 0 0 {name=l1 sig_type=std_logic lab=k35_bar_S}
C {devices/lab_pin.sym} -1120 2930 0 0 {name=l1 sig_type=std_logic lab=x36_S}
C {devices/lab_pin.sym} -1120 2950 0 0 {name=l1 sig_type=std_logic lab=x36_bar_S}
C {devices/lab_pin.sym} -1120 2970 0 0 {name=l1 sig_type=std_logic lab=k36_S}
C {devices/lab_pin.sym} -1120 2990 0 0 {name=l1 sig_type=std_logic lab=k36_bar_S}
C {devices/lab_pin.sym} -1120 3010 0 0 {name=l1 sig_type=std_logic lab=x37_S}
C {devices/lab_pin.sym} -1120 3030 0 0 {name=l1 sig_type=std_logic lab=x37_bar_S}
C {devices/lab_pin.sym} -1120 3050 0 0 {name=l1 sig_type=std_logic lab=k37_S}
C {devices/lab_pin.sym} -1120 3070 0 0 {name=l1 sig_type=std_logic lab=k37_bar_S}
C {devices/lab_pin.sym} -1120 3090 0 0 {name=l1 sig_type=std_logic lab=x38_S}
C {devices/lab_pin.sym} -1120 3110 0 0 {name=l1 sig_type=std_logic lab=x38_bar_S}
C {devices/lab_pin.sym} -1120 3130 0 0 {name=l1 sig_type=std_logic lab=k38_S}
C {devices/lab_pin.sym} -1120 3150 0 0 {name=l1 sig_type=std_logic lab=k38_bar_S}
C {devices/lab_pin.sym} -1120 3170 0 0 {name=l1 sig_type=std_logic lab=x39_S}
C {devices/lab_pin.sym} -1120 3190 0 0 {name=l1 sig_type=std_logic lab=x39_bar_S}
C {devices/lab_pin.sym} -1120 3210 0 0 {name=l1 sig_type=std_logic lab=k39_S}
C {devices/lab_pin.sym} -1120 3230 0 0 {name=l1 sig_type=std_logic lab=k39_bar_S}
C {devices/lab_pin.sym} -1120 3250 0 0 {name=l1 sig_type=std_logic lab=x40_S}
C {devices/lab_pin.sym} -1120 3270 0 0 {name=l1 sig_type=std_logic lab=x40_bar_S}
C {devices/lab_pin.sym} -1120 3290 0 0 {name=l1 sig_type=std_logic lab=k40_S}
C {devices/lab_pin.sym} -1120 3310 0 0 {name=l1 sig_type=std_logic lab=k40_bar_S}
C {devices/lab_pin.sym} -1120 3330 0 0 {name=l1 sig_type=std_logic lab=x41_S}
C {devices/lab_pin.sym} -1120 3350 0 0 {name=l1 sig_type=std_logic lab=x41_bar_S}
C {devices/lab_pin.sym} -1120 3370 0 0 {name=l1 sig_type=std_logic lab=k41_S}
C {devices/lab_pin.sym} -1120 3390 0 0 {name=l1 sig_type=std_logic lab=k41_bar_S}
C {devices/lab_pin.sym} -1120 3410 0 0 {name=l1 sig_type=std_logic lab=x42_S}
C {devices/lab_pin.sym} -1120 3430 0 0 {name=l1 sig_type=std_logic lab=x42_bar_S}
C {devices/lab_pin.sym} -1120 3450 0 0 {name=l1 sig_type=std_logic lab=k42_S}
C {devices/lab_pin.sym} -1120 3470 0 0 {name=l1 sig_type=std_logic lab=k42_bar_S}
C {devices/lab_pin.sym} -1120 3490 0 0 {name=l1 sig_type=std_logic lab=x43_S}
C {devices/lab_pin.sym} -1120 3510 0 0 {name=l1 sig_type=std_logic lab=x43_bar_S}
C {devices/lab_pin.sym} -1120 3530 0 0 {name=l1 sig_type=std_logic lab=k43_S}
C {devices/lab_pin.sym} -1120 3550 0 0 {name=l1 sig_type=std_logic lab=k43_bar_S}
C {devices/lab_pin.sym} -1120 3570 0 0 {name=l1 sig_type=std_logic lab=x44_S}
C {devices/lab_pin.sym} -1120 3590 0 0 {name=l1 sig_type=std_logic lab=x44_bar_S}
C {devices/lab_pin.sym} -1120 3610 0 0 {name=l1 sig_type=std_logic lab=k44_S}
C {devices/lab_pin.sym} -1120 3630 0 0 {name=l1 sig_type=std_logic lab=k44_bar_S}
C {devices/lab_pin.sym} -1120 3650 0 0 {name=l1 sig_type=std_logic lab=x45_S}
C {devices/lab_pin.sym} -1120 3670 0 0 {name=l1 sig_type=std_logic lab=x45_bar_S}
C {devices/lab_pin.sym} -1120 3690 0 0 {name=l1 sig_type=std_logic lab=k45_S}
C {devices/lab_pin.sym} -1120 3710 0 0 {name=l1 sig_type=std_logic lab=k45_bar_S}
C {devices/lab_pin.sym} -1120 3730 0 0 {name=l1 sig_type=std_logic lab=x46_S}
C {devices/lab_pin.sym} -1120 3750 0 0 {name=l1 sig_type=std_logic lab=x46_bar_S}
C {devices/lab_pin.sym} -1120 3770 0 0 {name=l1 sig_type=std_logic lab=k46_S}
C {devices/lab_pin.sym} -1120 3790 0 0 {name=l1 sig_type=std_logic lab=k46_bar_S}
C {devices/lab_pin.sym} -1120 3810 0 0 {name=l1 sig_type=std_logic lab=x47_S}
C {devices/lab_pin.sym} -1120 3830 0 0 {name=l1 sig_type=std_logic lab=x47_bar_S}
C {devices/lab_pin.sym} -1120 3850 0 0 {name=l1 sig_type=std_logic lab=k47_S}
C {devices/lab_pin.sym} -1120 3870 0 0 {name=l1 sig_type=std_logic lab=k47_bar_S}
C {devices/lab_pin.sym} -1120 3890 0 0 {name=l1 sig_type=std_logic lab=x48_S}
C {devices/lab_pin.sym} -1120 3910 0 0 {name=l1 sig_type=std_logic lab=x48_bar_S}
C {devices/lab_pin.sym} -1120 3930 0 0 {name=l1 sig_type=std_logic lab=k48_S}
C {devices/lab_pin.sym} -1120 3950 0 0 {name=l1 sig_type=std_logic lab=k48_bar_S}
C {devices/lab_pin.sym} -1120 3970 0 0 {name=l1 sig_type=std_logic lab=x49_S}
C {devices/lab_pin.sym} -1120 3990 0 0 {name=l1 sig_type=std_logic lab=x49_bar_S}
C {devices/lab_pin.sym} -1120 4010 0 0 {name=l1 sig_type=std_logic lab=k49_S}
C {devices/lab_pin.sym} -1120 4030 0 0 {name=l1 sig_type=std_logic lab=k49_bar_S}
C {devices/lab_pin.sym} -1120 4050 0 0 {name=l1 sig_type=std_logic lab=x50_S}
C {devices/lab_pin.sym} -1120 4070 0 0 {name=l1 sig_type=std_logic lab=x50_bar_S}
C {devices/lab_pin.sym} -1120 4090 0 0 {name=l1 sig_type=std_logic lab=k50_S}
C {devices/lab_pin.sym} -1120 4110 0 0 {name=l1 sig_type=std_logic lab=k50_bar_S}
C {devices/lab_pin.sym} -1120 4130 0 0 {name=l1 sig_type=std_logic lab=x51_S}
C {devices/lab_pin.sym} -1120 4150 0 0 {name=l1 sig_type=std_logic lab=x51_bar_S}
C {devices/lab_pin.sym} -1120 4170 0 0 {name=l1 sig_type=std_logic lab=k51_S}
C {devices/lab_pin.sym} -1120 4190 0 0 {name=l1 sig_type=std_logic lab=k51_bar_S}
C {devices/lab_pin.sym} -1120 4210 0 0 {name=l1 sig_type=std_logic lab=x52_S}
C {devices/lab_pin.sym} -1120 4230 0 0 {name=l1 sig_type=std_logic lab=x52_bar_S}
C {devices/lab_pin.sym} -1120 4250 0 0 {name=l1 sig_type=std_logic lab=k52_S}
C {devices/lab_pin.sym} -1120 4270 0 0 {name=l1 sig_type=std_logic lab=k52_bar_S}
C {devices/lab_pin.sym} -1120 4290 0 0 {name=l1 sig_type=std_logic lab=x53_S}
C {devices/lab_pin.sym} -1120 4310 0 0 {name=l1 sig_type=std_logic lab=x53_bar_S}
C {devices/lab_pin.sym} -1120 4330 0 0 {name=l1 sig_type=std_logic lab=k53_S}
C {devices/lab_pin.sym} -1120 4350 0 0 {name=l1 sig_type=std_logic lab=k53_bar_S}
C {devices/lab_pin.sym} -1120 4370 0 0 {name=l1 sig_type=std_logic lab=x54_S}
C {devices/lab_pin.sym} -1120 4390 0 0 {name=l1 sig_type=std_logic lab=x54_bar_S}
C {devices/lab_pin.sym} -1120 4410 0 0 {name=l1 sig_type=std_logic lab=k54_S}
C {devices/lab_pin.sym} -1120 4430 0 0 {name=l1 sig_type=std_logic lab=k54_bar_S}
C {devices/lab_pin.sym} -1120 4450 0 0 {name=l1 sig_type=std_logic lab=x55_S}
C {devices/lab_pin.sym} -1120 4470 0 0 {name=l1 sig_type=std_logic lab=x55_bar_S}
C {devices/lab_pin.sym} -1120 4490 0 0 {name=l1 sig_type=std_logic lab=k55_S}
C {devices/lab_pin.sym} -1120 4510 0 0 {name=l1 sig_type=std_logic lab=k55_bar_S}
C {devices/lab_pin.sym} -1120 4530 0 0 {name=l1 sig_type=std_logic lab=x56_S}
C {devices/lab_pin.sym} -1120 4550 0 0 {name=l1 sig_type=std_logic lab=x56_bar_S}
C {devices/lab_pin.sym} -1120 4570 0 0 {name=l1 sig_type=std_logic lab=k56_S}
C {devices/lab_pin.sym} -1120 4590 0 0 {name=l1 sig_type=std_logic lab=k56_bar_S}
C {devices/lab_pin.sym} -1120 4610 0 0 {name=l1 sig_type=std_logic lab=x57_S}
C {devices/lab_pin.sym} -1120 4630 0 0 {name=l1 sig_type=std_logic lab=x57_bar_S}
C {devices/lab_pin.sym} -1120 4650 0 0 {name=l1 sig_type=std_logic lab=k57_S}
C {devices/lab_pin.sym} -1120 4670 0 0 {name=l1 sig_type=std_logic lab=k57_bar_S}
C {devices/lab_pin.sym} -1120 4690 0 0 {name=l1 sig_type=std_logic lab=x58_S}
C {devices/lab_pin.sym} -1120 4710 0 0 {name=l1 sig_type=std_logic lab=x58_bar_S}
C {devices/lab_pin.sym} -1120 4730 0 0 {name=l1 sig_type=std_logic lab=k58_S}
C {devices/lab_pin.sym} -1120 4750 0 0 {name=l1 sig_type=std_logic lab=k58_bar_S}
C {devices/lab_pin.sym} -1120 4770 0 0 {name=l1 sig_type=std_logic lab=x59_S}
C {devices/lab_pin.sym} -1120 4790 0 0 {name=l1 sig_type=std_logic lab=x59_bar_S}
C {devices/lab_pin.sym} -1120 4810 0 0 {name=l1 sig_type=std_logic lab=k59_S}
C {devices/lab_pin.sym} -1120 4830 0 0 {name=l1 sig_type=std_logic lab=k59_bar_S}
C {devices/lab_pin.sym} -1120 4850 0 0 {name=l1 sig_type=std_logic lab=x60_S}
C {devices/lab_pin.sym} -1120 4870 0 0 {name=l1 sig_type=std_logic lab=x60_bar_S}
C {devices/lab_pin.sym} -1120 4890 0 0 {name=l1 sig_type=std_logic lab=k60_S}
C {devices/lab_pin.sym} -1120 4910 0 0 {name=l1 sig_type=std_logic lab=k60_bar_S}
C {devices/lab_pin.sym} -1120 4930 0 0 {name=l1 sig_type=std_logic lab=x61_S}
C {devices/lab_pin.sym} -1120 4950 0 0 {name=l1 sig_type=std_logic lab=x61_bar_S}
C {devices/lab_pin.sym} -1120 4970 0 0 {name=l1 sig_type=std_logic lab=k61_S}
C {devices/lab_pin.sym} -1120 4990 0 0 {name=l1 sig_type=std_logic lab=k61_bar_S}
C {devices/lab_pin.sym} -1120 5010 0 0 {name=l1 sig_type=std_logic lab=x62_S}
C {devices/lab_pin.sym} -1120 5030 0 0 {name=l1 sig_type=std_logic lab=x62_bar_S}
C {devices/lab_pin.sym} -1120 5050 0 0 {name=l1 sig_type=std_logic lab=k62_S}
C {devices/lab_pin.sym} -1120 5070 0 0 {name=l1 sig_type=std_logic lab=k62_bar_S}
C {devices/lab_pin.sym} -1120 5090 0 0 {name=l1 sig_type=std_logic lab=x63_S}
C {devices/lab_pin.sym} -1120 5110 0 0 {name=l1 sig_type=std_logic lab=x63_bar_S}
C {devices/lab_pin.sym} -1120 5130 0 0 {name=l1 sig_type=std_logic lab=k63_S}
C {devices/lab_pin.sym} -1120 5150 0 0 {name=l1 sig_type=std_logic lab=k63_bar_S}
C {devices/lab_pin.sym} -1480 40 0 0 {name=l1 sig_type=std_logic lab=s0_norm}
C {devices/lab_pin.sym} -1480 60 0 0 {name=l1 sig_type=std_logic lab=s0_norm_bar}
C {devices/lab_pin.sym} -1480 80 0 0 {name=l1 sig_type=std_logic lab=s1_norm}
C {devices/lab_pin.sym} -1480 100 0 0 {name=l1 sig_type=std_logic lab=s1_norm_bar}
C {devices/lab_pin.sym} -1480 120 0 0 {name=l1 sig_type=std_logic lab=s2_norm}
C {devices/lab_pin.sym} -1480 140 0 0 {name=l1 sig_type=std_logic lab=s2_norm_bar}
C {devices/lab_pin.sym} -1480 160 0 0 {name=l1 sig_type=std_logic lab=s3_norm}
C {devices/lab_pin.sym} -1480 180 0 0 {name=l1 sig_type=std_logic lab=s3_norm_bar}
C {devices/lab_pin.sym} -1480 200 0 0 {name=l1 sig_type=std_logic lab=s4_norm}
C {devices/lab_pin.sym} -1480 220 0 0 {name=l1 sig_type=std_logic lab=s4_norm_bar}
C {devices/lab_pin.sym} -1480 240 0 0 {name=l1 sig_type=std_logic lab=s5_norm}
C {devices/lab_pin.sym} -1480 260 0 0 {name=l1 sig_type=std_logic lab=s5_norm_bar}
C {devices/lab_pin.sym} -1480 280 0 0 {name=l1 sig_type=std_logic lab=s6_norm}
C {devices/lab_pin.sym} -1480 300 0 0 {name=l1 sig_type=std_logic lab=s6_norm_bar}
C {devices/lab_pin.sym} -1480 320 0 0 {name=l1 sig_type=std_logic lab=s7_norm}
C {devices/lab_pin.sym} -1480 340 0 0 {name=l1 sig_type=std_logic lab=s7_norm_bar}
C {devices/lab_pin.sym} -1480 360 0 0 {name=l1 sig_type=std_logic lab=s8_norm}
C {devices/lab_pin.sym} -1480 380 0 0 {name=l1 sig_type=std_logic lab=s8_norm_bar}
C {devices/lab_pin.sym} -1480 400 0 0 {name=l1 sig_type=std_logic lab=s9_norm}
C {devices/lab_pin.sym} -1480 420 0 0 {name=l1 sig_type=std_logic lab=s9_norm_bar}
C {devices/lab_pin.sym} -1480 440 0 0 {name=l1 sig_type=std_logic lab=s10_norm}
C {devices/lab_pin.sym} -1480 460 0 0 {name=l1 sig_type=std_logic lab=s10_norm_bar}
C {devices/lab_pin.sym} -1480 480 0 0 {name=l1 sig_type=std_logic lab=s11_norm}
C {devices/lab_pin.sym} -1480 500 0 0 {name=l1 sig_type=std_logic lab=s11_norm_bar}
C {devices/lab_pin.sym} -1480 520 0 0 {name=l1 sig_type=std_logic lab=s12_norm}
C {devices/lab_pin.sym} -1480 540 0 0 {name=l1 sig_type=std_logic lab=s12_norm_bar}
C {devices/lab_pin.sym} -1480 560 0 0 {name=l1 sig_type=std_logic lab=s13_norm}
C {devices/lab_pin.sym} -1480 580 0 0 {name=l1 sig_type=std_logic lab=s13_norm_bar}
C {devices/lab_pin.sym} -1480 600 0 0 {name=l1 sig_type=std_logic lab=s14_norm}
C {devices/lab_pin.sym} -1480 620 0 0 {name=l1 sig_type=std_logic lab=s14_norm_bar}
C {devices/lab_pin.sym} -1480 640 0 0 {name=l1 sig_type=std_logic lab=s15_norm}
C {devices/lab_pin.sym} -1480 660 0 0 {name=l1 sig_type=std_logic lab=s15_norm_bar}
C {devices/lab_pin.sym} -1480 680 0 0 {name=l1 sig_type=std_logic lab=s16_norm}
C {devices/lab_pin.sym} -1480 700 0 0 {name=l1 sig_type=std_logic lab=s16_norm_bar}
C {devices/lab_pin.sym} -1480 720 0 0 {name=l1 sig_type=std_logic lab=s17_norm}
C {devices/lab_pin.sym} -1480 740 0 0 {name=l1 sig_type=std_logic lab=s17_norm_bar}
C {devices/lab_pin.sym} -1480 760 0 0 {name=l1 sig_type=std_logic lab=s18_norm}
C {devices/lab_pin.sym} -1480 780 0 0 {name=l1 sig_type=std_logic lab=s18_norm_bar}
C {devices/lab_pin.sym} -1480 800 0 0 {name=l1 sig_type=std_logic lab=s19_norm}
C {devices/lab_pin.sym} -1480 820 0 0 {name=l1 sig_type=std_logic lab=s19_norm_bar}
C {devices/lab_pin.sym} -1480 840 0 0 {name=l1 sig_type=std_logic lab=s20_norm}
C {devices/lab_pin.sym} -1480 860 0 0 {name=l1 sig_type=std_logic lab=s20_norm_bar}
C {devices/lab_pin.sym} -1480 880 0 0 {name=l1 sig_type=std_logic lab=s21_norm}
C {devices/lab_pin.sym} -1480 900 0 0 {name=l1 sig_type=std_logic lab=s21_norm_bar}
C {devices/lab_pin.sym} -1480 920 0 0 {name=l1 sig_type=std_logic lab=s22_norm}
C {devices/lab_pin.sym} -1480 940 0 0 {name=l1 sig_type=std_logic lab=s22_norm_bar}
C {devices/lab_pin.sym} -1480 960 0 0 {name=l1 sig_type=std_logic lab=s23_norm}
C {devices/lab_pin.sym} -1480 980 0 0 {name=l1 sig_type=std_logic lab=s23_norm_bar}
C {devices/lab_pin.sym} -1480 1000 0 0 {name=l1 sig_type=std_logic lab=s24_norm}
C {devices/lab_pin.sym} -1480 1020 0 0 {name=l1 sig_type=std_logic lab=s24_norm_bar}
C {devices/lab_pin.sym} -1480 1040 0 0 {name=l1 sig_type=std_logic lab=s25_norm}
C {devices/lab_pin.sym} -1480 1060 0 0 {name=l1 sig_type=std_logic lab=s25_norm_bar}
C {devices/lab_pin.sym} -1480 1080 0 0 {name=l1 sig_type=std_logic lab=s26_norm}
C {devices/lab_pin.sym} -1480 1100 0 0 {name=l1 sig_type=std_logic lab=s26_norm_bar}
C {devices/lab_pin.sym} -1480 1120 0 0 {name=l1 sig_type=std_logic lab=s27_norm}
C {devices/lab_pin.sym} -1480 1140 0 0 {name=l1 sig_type=std_logic lab=s27_norm_bar}
C {devices/lab_pin.sym} -1480 1160 0 0 {name=l1 sig_type=std_logic lab=s28_norm}
C {devices/lab_pin.sym} -1480 1180 0 0 {name=l1 sig_type=std_logic lab=s28_norm_bar}
C {devices/lab_pin.sym} -1480 1200 0 0 {name=l1 sig_type=std_logic lab=s29_norm}
C {devices/lab_pin.sym} -1480 1220 0 0 {name=l1 sig_type=std_logic lab=s29_norm_bar}
C {devices/lab_pin.sym} -1480 1240 0 0 {name=l1 sig_type=std_logic lab=s30_norm}
C {devices/lab_pin.sym} -1480 1260 0 0 {name=l1 sig_type=std_logic lab=s30_norm_bar}
C {devices/lab_pin.sym} -1480 1280 0 0 {name=l1 sig_type=std_logic lab=s31_norm}
C {devices/lab_pin.sym} -1480 1300 0 0 {name=l1 sig_type=std_logic lab=s31_norm_bar}
C {devices/lab_pin.sym} -1480 1320 0 0 {name=l1 sig_type=std_logic lab=s32_norm}
C {devices/lab_pin.sym} -1480 1340 0 0 {name=l1 sig_type=std_logic lab=s32_norm_bar}
C {devices/lab_pin.sym} -1480 1360 0 0 {name=l1 sig_type=std_logic lab=s33_norm}
C {devices/lab_pin.sym} -1480 1380 0 0 {name=l1 sig_type=std_logic lab=s33_norm_bar}
C {devices/lab_pin.sym} -1480 1400 0 0 {name=l1 sig_type=std_logic lab=s34_norm}
C {devices/lab_pin.sym} -1480 1420 0 0 {name=l1 sig_type=std_logic lab=s34_norm_bar}
C {devices/lab_pin.sym} -1480 1440 0 0 {name=l1 sig_type=std_logic lab=s35_norm}
C {devices/lab_pin.sym} -1480 1460 0 0 {name=l1 sig_type=std_logic lab=s35_norm_bar}
C {devices/lab_pin.sym} -1480 1480 0 0 {name=l1 sig_type=std_logic lab=s36_norm}
C {devices/lab_pin.sym} -1480 1500 0 0 {name=l1 sig_type=std_logic lab=s36_norm_bar}
C {devices/lab_pin.sym} -1480 1520 0 0 {name=l1 sig_type=std_logic lab=s37_norm}
C {devices/lab_pin.sym} -1480 1540 0 0 {name=l1 sig_type=std_logic lab=s37_norm_bar}
C {devices/lab_pin.sym} -1480 1560 0 0 {name=l1 sig_type=std_logic lab=s38_norm}
C {devices/lab_pin.sym} -1480 1580 0 0 {name=l1 sig_type=std_logic lab=s38_norm_bar}
C {devices/lab_pin.sym} -1480 1600 0 0 {name=l1 sig_type=std_logic lab=s39_norm}
C {devices/lab_pin.sym} -1480 1620 0 0 {name=l1 sig_type=std_logic lab=s39_norm_bar}
C {devices/lab_pin.sym} -1480 1640 0 0 {name=l1 sig_type=std_logic lab=s40_norm}
C {devices/lab_pin.sym} -1480 1660 0 0 {name=l1 sig_type=std_logic lab=s40_norm_bar}
C {devices/lab_pin.sym} -1480 1680 0 0 {name=l1 sig_type=std_logic lab=s41_norm}
C {devices/lab_pin.sym} -1480 1700 0 0 {name=l1 sig_type=std_logic lab=s41_norm_bar}
C {devices/lab_pin.sym} -1480 1720 0 0 {name=l1 sig_type=std_logic lab=s42_norm}
C {devices/lab_pin.sym} -1480 1740 0 0 {name=l1 sig_type=std_logic lab=s42_norm_bar}
C {devices/lab_pin.sym} -1480 1760 0 0 {name=l1 sig_type=std_logic lab=s43_norm}
C {devices/lab_pin.sym} -1480 1780 0 0 {name=l1 sig_type=std_logic lab=s43_norm_bar}
C {devices/lab_pin.sym} -1480 1800 0 0 {name=l1 sig_type=std_logic lab=s44_norm}
C {devices/lab_pin.sym} -1480 1820 0 0 {name=l1 sig_type=std_logic lab=s44_norm_bar}
C {devices/lab_pin.sym} -1480 1840 0 0 {name=l1 sig_type=std_logic lab=s45_norm}
C {devices/lab_pin.sym} -1480 1860 0 0 {name=l1 sig_type=std_logic lab=s45_norm_bar}
C {devices/lab_pin.sym} -1480 1880 0 0 {name=l1 sig_type=std_logic lab=s46_norm}
C {devices/lab_pin.sym} -1480 1900 0 0 {name=l1 sig_type=std_logic lab=s46_norm_bar}
C {devices/lab_pin.sym} -1480 1920 0 0 {name=l1 sig_type=std_logic lab=s47_norm}
C {devices/lab_pin.sym} -1480 1940 0 0 {name=l1 sig_type=std_logic lab=s47_norm_bar}
C {devices/lab_pin.sym} -1480 1960 0 0 {name=l1 sig_type=std_logic lab=s48_norm}
C {devices/lab_pin.sym} -1480 1980 0 0 {name=l1 sig_type=std_logic lab=s48_norm_bar}
C {devices/lab_pin.sym} -1480 2000 0 0 {name=l1 sig_type=std_logic lab=s49_norm}
C {devices/lab_pin.sym} -1480 2020 0 0 {name=l1 sig_type=std_logic lab=s49_norm_bar}
C {devices/lab_pin.sym} -1480 2040 0 0 {name=l1 sig_type=std_logic lab=s50_norm}
C {devices/lab_pin.sym} -1480 2060 0 0 {name=l1 sig_type=std_logic lab=s50_norm_bar}
C {devices/lab_pin.sym} -1480 2080 0 0 {name=l1 sig_type=std_logic lab=s51_norm}
C {devices/lab_pin.sym} -1480 2100 0 0 {name=l1 sig_type=std_logic lab=s51_norm_bar}
C {devices/lab_pin.sym} -1480 2120 0 0 {name=l1 sig_type=std_logic lab=s52_norm}
C {devices/lab_pin.sym} -1480 2140 0 0 {name=l1 sig_type=std_logic lab=s52_norm_bar}
C {devices/lab_pin.sym} -1480 2160 0 0 {name=l1 sig_type=std_logic lab=s53_norm}
C {devices/lab_pin.sym} -1480 2180 0 0 {name=l1 sig_type=std_logic lab=s53_norm_bar}
C {devices/lab_pin.sym} -1480 2200 0 0 {name=l1 sig_type=std_logic lab=s54_norm}
C {devices/lab_pin.sym} -1480 2220 0 0 {name=l1 sig_type=std_logic lab=s54_norm_bar}
C {devices/lab_pin.sym} -1480 2240 0 0 {name=l1 sig_type=std_logic lab=s55_norm}
C {devices/lab_pin.sym} -1480 2260 0 0 {name=l1 sig_type=std_logic lab=s55_norm_bar}
C {devices/lab_pin.sym} -1480 2280 0 0 {name=l1 sig_type=std_logic lab=s56_norm}
C {devices/lab_pin.sym} -1480 2300 0 0 {name=l1 sig_type=std_logic lab=s56_norm_bar}
C {devices/lab_pin.sym} -1480 2320 0 0 {name=l1 sig_type=std_logic lab=s57_norm}
C {devices/lab_pin.sym} -1480 2340 0 0 {name=l1 sig_type=std_logic lab=s57_norm_bar}
C {devices/lab_pin.sym} -1480 2360 0 0 {name=l1 sig_type=std_logic lab=s58_norm}
C {devices/lab_pin.sym} -1480 2380 0 0 {name=l1 sig_type=std_logic lab=s58_norm_bar}
C {devices/lab_pin.sym} -1480 2400 0 0 {name=l1 sig_type=std_logic lab=s59_norm}
C {devices/lab_pin.sym} -1480 2420 0 0 {name=l1 sig_type=std_logic lab=s59_norm_bar}
C {devices/lab_pin.sym} -1480 2440 0 0 {name=l1 sig_type=std_logic lab=s60_norm}
C {devices/lab_pin.sym} -1480 2460 0 0 {name=l1 sig_type=std_logic lab=s60_norm_bar}
C {devices/lab_pin.sym} -1480 2480 0 0 {name=l1 sig_type=std_logic lab=s61_norm}
C {devices/lab_pin.sym} -1480 2500 0 0 {name=l1 sig_type=std_logic lab=s61_norm_bar}
C {devices/lab_pin.sym} -1480 2520 0 0 {name=l1 sig_type=std_logic lab=s62_norm}
C {devices/lab_pin.sym} -1480 2540 0 0 {name=l1 sig_type=std_logic lab=s62_norm_bar}
C {devices/lab_pin.sym} -1480 2560 0 0 {name=l1 sig_type=std_logic lab=s63_norm}
C {devices/lab_pin.sym} -1480 2580 0 0 {name=l1 sig_type=std_logic lab=s63_norm_bar}
C {devices/vsource.sym} -920 -60 0 0 {name=V1 value=3}
C {devices/vsource.sym} -430 20 3 0 {name=Vx0 value=x0}
C {devices/vsource.sym} -430 40 3 0 {name=Vx0_bar value=x0_bar}
C {devices/vsource.sym} -430 60 3 0 {name=Vk0 value=k0}
C {devices/vsource.sym} -430 80 3 0 {name=Vk0_bar value=k0_bar}
C {devices/vsource.sym} -430 100 3 0 {name=Vx1 value=x1}
C {devices/vsource.sym} -430 120 3 0 {name=Vx1_bar value=x1_bar}
C {devices/vsource.sym} -430 140 3 0 {name=Vk1 value=k1}
C {devices/vsource.sym} -430 160 3 0 {name=Vk1_bar value=k1_bar}
C {devices/vsource.sym} -430 180 3 0 {name=Vx2 value=x2}
C {devices/vsource.sym} -430 200 3 0 {name=Vx2_bar value=x2_bar}
C {devices/vsource.sym} -430 220 3 0 {name=Vk2 value=k2}
C {devices/vsource.sym} -430 240 3 0 {name=Vk2_bar value=k2_bar}
C {devices/vsource.sym} -430 260 3 0 {name=Vx3 value=x3}
C {devices/vsource.sym} -430 280 3 0 {name=Vx3_bar value=x3_bar}
C {devices/vsource.sym} -430 300 3 0 {name=Vk3 value=k3}
C {devices/vsource.sym} -430 320 3 0 {name=Vk3_bar value=k3_bar}
C {devices/vsource.sym} -430 340 3 0 {name=Vx4 value=x4}
C {devices/vsource.sym} -430 360 3 0 {name=Vx4_bar value=x4_bar}
C {devices/vsource.sym} -430 380 3 0 {name=Vk4 value=k4}
C {devices/vsource.sym} -430 400 3 0 {name=Vk4_bar value=k4_bar}
C {devices/vsource.sym} -430 420 3 0 {name=Vx5 value=x5}
C {devices/vsource.sym} -430 440 3 0 {name=Vx5_bar value=x5_bar}
C {devices/vsource.sym} -430 460 3 0 {name=Vk5 value=k5}
C {devices/vsource.sym} -430 480 3 0 {name=Vk5_bar value=k5_bar}
C {devices/vsource.sym} -430 500 3 0 {name=Vx6 value=x6}
C {devices/vsource.sym} -430 520 3 0 {name=Vx6_bar value=x6_bar}
C {devices/vsource.sym} -430 540 3 0 {name=Vk6 value=k6}
C {devices/vsource.sym} -430 560 3 0 {name=Vk6_bar value=k6_bar}
C {devices/vsource.sym} -430 580 3 0 {name=Vx7 value=x7}
C {devices/vsource.sym} -430 600 3 0 {name=Vx7_bar value=x7_bar}
C {devices/vsource.sym} -430 620 3 0 {name=Vk7 value=k7}
C {devices/vsource.sym} -430 640 3 0 {name=Vk7_bar value=k7_bar}
C {devices/vsource.sym} -430 660 3 0 {name=Vx8 value=x8}
C {devices/vsource.sym} -430 680 3 0 {name=Vx8_bar value=x8_bar}
C {devices/vsource.sym} -430 700 3 0 {name=Vk8 value=k8}
C {devices/vsource.sym} -430 720 3 0 {name=Vk8_bar value=k8_bar}
C {devices/vsource.sym} -430 740 3 0 {name=Vx9 value=x9}
C {devices/vsource.sym} -430 760 3 0 {name=Vx9_bar value=x9_bar}
C {devices/vsource.sym} -430 780 3 0 {name=Vk9 value=k9}
C {devices/vsource.sym} -430 800 3 0 {name=Vk9_bar value=k9_bar}
C {devices/vsource.sym} -430 820 3 0 {name=Vx10 value=x10}
C {devices/vsource.sym} -430 840 3 0 {name=Vx10_bar value=x10_bar}
C {devices/vsource.sym} -430 860 3 0 {name=Vk10 value=k10}
C {devices/vsource.sym} -430 880 3 0 {name=Vk10_bar value=k10_bar}
C {devices/vsource.sym} -430 900 3 0 {name=Vx11 value=x11}
C {devices/vsource.sym} -430 920 3 0 {name=Vx11_bar value=x11_bar}
C {devices/vsource.sym} -430 940 3 0 {name=Vk11 value=k11}
C {devices/vsource.sym} -430 960 3 0 {name=Vk11_bar value=k11_bar}
C {devices/vsource.sym} -430 980 3 0 {name=Vx12 value=x12}
C {devices/vsource.sym} -430 1000 3 0 {name=Vx12_bar value=x12_bar}
C {devices/vsource.sym} -430 1020 3 0 {name=Vk12 value=k12}
C {devices/vsource.sym} -430 1040 3 0 {name=Vk12_bar value=k12_bar}
C {devices/vsource.sym} -430 1060 3 0 {name=Vx13 value=x13}
C {devices/vsource.sym} -430 1080 3 0 {name=Vx13_bar value=x13_bar}
C {devices/vsource.sym} -430 1100 3 0 {name=Vk13 value=k13}
C {devices/vsource.sym} -430 1120 3 0 {name=Vk13_bar value=k13_bar}
C {devices/vsource.sym} -430 1140 3 0 {name=Vx14 value=x14}
C {devices/vsource.sym} -430 1160 3 0 {name=Vx14_bar value=x14_bar}
C {devices/vsource.sym} -430 1180 3 0 {name=Vk14 value=k14}
C {devices/vsource.sym} -430 1200 3 0 {name=Vk14_bar value=k14_bar}
C {devices/vsource.sym} -430 1220 3 0 {name=Vx15 value=x15}
C {devices/vsource.sym} -430 1240 3 0 {name=Vx15_bar value=x15_bar}
C {devices/vsource.sym} -430 1260 3 0 {name=Vk15 value=k15}
C {devices/vsource.sym} -430 1280 3 0 {name=Vk15_bar value=k15_bar}
C {devices/vsource.sym} -430 1300 3 0 {name=Vx16 value=x16}
C {devices/vsource.sym} -430 1320 3 0 {name=Vx16_bar value=x16_bar}
C {devices/vsource.sym} -430 1340 3 0 {name=Vk16 value=k16}
C {devices/vsource.sym} -430 1360 3 0 {name=Vk16_bar value=k16_bar}
C {devices/vsource.sym} -430 1380 3 0 {name=Vx17 value=x17}
C {devices/vsource.sym} -430 1400 3 0 {name=Vx17_bar value=x17_bar}
C {devices/vsource.sym} -430 1420 3 0 {name=Vk17 value=k17}
C {devices/vsource.sym} -430 1440 3 0 {name=Vk17_bar value=k17_bar}
C {devices/vsource.sym} -430 1460 3 0 {name=Vx18 value=x18}
C {devices/vsource.sym} -430 1480 3 0 {name=Vx18_bar value=x18_bar}
C {devices/vsource.sym} -430 1500 3 0 {name=Vk18 value=k18}
C {devices/vsource.sym} -430 1520 3 0 {name=Vk18_bar value=k18_bar}
C {devices/vsource.sym} -430 1540 3 0 {name=Vx19 value=x19}
C {devices/vsource.sym} -430 1560 3 0 {name=Vx19_bar value=x19_bar}
C {devices/vsource.sym} -430 1580 3 0 {name=Vk19 value=k19}
C {devices/vsource.sym} -430 1600 3 0 {name=Vk19_bar value=k19_bar}
C {devices/vsource.sym} -430 1620 3 0 {name=Vx20 value=x20}
C {devices/vsource.sym} -430 1640 3 0 {name=Vx20_bar value=x20_bar}
C {devices/vsource.sym} -430 1660 3 0 {name=Vk20 value=k20}
C {devices/vsource.sym} -430 1680 3 0 {name=Vk20_bar value=k20_bar}
C {devices/vsource.sym} -430 1700 3 0 {name=Vx21 value=x21}
C {devices/vsource.sym} -430 1720 3 0 {name=Vx21_bar value=x21_bar}
C {devices/vsource.sym} -430 1740 3 0 {name=Vk21 value=k21}
C {devices/vsource.sym} -430 1760 3 0 {name=Vk21_bar value=k21_bar}
C {devices/vsource.sym} -430 1780 3 0 {name=Vx22 value=x22}
C {devices/vsource.sym} -430 1800 3 0 {name=Vx22_bar value=x22_bar}
C {devices/vsource.sym} -430 1820 3 0 {name=Vk22 value=k22}
C {devices/vsource.sym} -430 1840 3 0 {name=Vk22_bar value=k22_bar}
C {devices/vsource.sym} -430 1860 3 0 {name=Vx23 value=x23}
C {devices/vsource.sym} -430 1880 3 0 {name=Vx23_bar value=x23_bar}
C {devices/vsource.sym} -430 1900 3 0 {name=Vk23 value=k23}
C {devices/vsource.sym} -430 1920 3 0 {name=Vk23_bar value=k23_bar}
C {devices/vsource.sym} -430 1940 3 0 {name=Vx24 value=x24}
C {devices/vsource.sym} -430 1960 3 0 {name=Vx24_bar value=x24_bar}
C {devices/vsource.sym} -430 1980 3 0 {name=Vk24 value=k24}
C {devices/vsource.sym} -430 2000 3 0 {name=Vk24_bar value=k24_bar}
C {devices/vsource.sym} -430 2020 3 0 {name=Vx25 value=x25}
C {devices/vsource.sym} -430 2040 3 0 {name=Vx25_bar value=x25_bar}
C {devices/vsource.sym} -430 2060 3 0 {name=Vk25 value=k25}
C {devices/vsource.sym} -430 2080 3 0 {name=Vk25_bar value=k25_bar}
C {devices/vsource.sym} -430 2100 3 0 {name=Vx26 value=x26}
C {devices/vsource.sym} -430 2120 3 0 {name=Vx26_bar value=x26_bar}
C {devices/vsource.sym} -430 2140 3 0 {name=Vk26 value=k26}
C {devices/vsource.sym} -430 2160 3 0 {name=Vk26_bar value=k26_bar}
C {devices/vsource.sym} -430 2180 3 0 {name=Vx27 value=x27}
C {devices/vsource.sym} -430 2200 3 0 {name=Vx27_bar value=x27_bar}
C {devices/vsource.sym} -430 2220 3 0 {name=Vk27 value=k27}
C {devices/vsource.sym} -430 2240 3 0 {name=Vk27_bar value=k27_bar}
C {devices/vsource.sym} -430 2260 3 0 {name=Vx28 value=x28}
C {devices/vsource.sym} -430 2280 3 0 {name=Vx28_bar value=x28_bar}
C {devices/vsource.sym} -430 2300 3 0 {name=Vk28 value=k28}
C {devices/vsource.sym} -430 2320 3 0 {name=Vk28_bar value=k28_bar}
C {devices/vsource.sym} -430 2340 3 0 {name=Vx29 value=x29}
C {devices/vsource.sym} -430 2360 3 0 {name=Vx29_bar value=x29_bar}
C {devices/vsource.sym} -430 2380 3 0 {name=Vk29 value=k29}
C {devices/vsource.sym} -430 2400 3 0 {name=Vk29_bar value=k29_bar}
C {devices/vsource.sym} -430 2420 3 0 {name=Vx30 value=x30}
C {devices/vsource.sym} -430 2440 3 0 {name=Vx30_bar value=x30_bar}
C {devices/vsource.sym} -430 2460 3 0 {name=Vk30 value=k30}
C {devices/vsource.sym} -430 2480 3 0 {name=Vk30_bar value=k30_bar}
C {devices/vsource.sym} -430 2500 3 0 {name=Vx31 value=x31}
C {devices/vsource.sym} -430 2520 3 0 {name=Vx31_bar value=x31_bar}
C {devices/vsource.sym} -430 2540 3 0 {name=Vk31 value=k31}
C {devices/vsource.sym} -430 2560 3 0 {name=Vk31_bar value=k31_bar}
C {devices/vsource.sym} -430 2580 3 0 {name=Vx32 value=x32}
C {devices/vsource.sym} -430 2600 3 0 {name=Vx32_bar value=x32_bar}
C {devices/vsource.sym} -430 2620 3 0 {name=Vk32 value=k32}
C {devices/vsource.sym} -430 2640 3 0 {name=Vk32_bar value=k32_bar}
C {devices/vsource.sym} -430 2660 3 0 {name=Vx33 value=x33}
C {devices/vsource.sym} -430 2680 3 0 {name=Vx33_bar value=x33_bar}
C {devices/vsource.sym} -430 2700 3 0 {name=Vk33 value=k33}
C {devices/vsource.sym} -430 2720 3 0 {name=Vk33_bar value=k33_bar}
C {devices/vsource.sym} -430 2740 3 0 {name=Vx34 value=x34}
C {devices/vsource.sym} -430 2760 3 0 {name=Vx34_bar value=x34_bar}
C {devices/vsource.sym} -430 2780 3 0 {name=Vk34 value=k34}
C {devices/vsource.sym} -430 2800 3 0 {name=Vk34_bar value=k34_bar}
C {devices/vsource.sym} -430 2820 3 0 {name=Vx35 value=x35}
C {devices/vsource.sym} -430 2840 3 0 {name=Vx35_bar value=x35_bar}
C {devices/vsource.sym} -430 2860 3 0 {name=Vk35 value=k35}
C {devices/vsource.sym} -430 2880 3 0 {name=Vk35_bar value=k35_bar}
C {devices/vsource.sym} -430 2900 3 0 {name=Vx36 value=x36}
C {devices/vsource.sym} -430 2920 3 0 {name=Vx36_bar value=x36_bar}
C {devices/vsource.sym} -430 2940 3 0 {name=Vk36 value=k36}
C {devices/vsource.sym} -430 2960 3 0 {name=Vk36_bar value=k36_bar}
C {devices/vsource.sym} -430 2980 3 0 {name=Vx37 value=x37}
C {devices/vsource.sym} -430 3000 3 0 {name=Vx37_bar value=x37_bar}
C {devices/vsource.sym} -430 3020 3 0 {name=Vk37 value=k37}
C {devices/vsource.sym} -430 3040 3 0 {name=Vk37_bar value=k37_bar}
C {devices/vsource.sym} -430 3060 3 0 {name=Vx38 value=x38}
C {devices/vsource.sym} -430 3080 3 0 {name=Vx38_bar value=x38_bar}
C {devices/vsource.sym} -430 3100 3 0 {name=Vk38 value=k38}
C {devices/vsource.sym} -430 3120 3 0 {name=Vk38_bar value=k38_bar}
C {devices/vsource.sym} -430 3140 3 0 {name=Vx39 value=x39}
C {devices/vsource.sym} -430 3160 3 0 {name=Vx39_bar value=x39_bar}
C {devices/vsource.sym} -430 3180 3 0 {name=Vk39 value=k39}
C {devices/vsource.sym} -430 3200 3 0 {name=Vk39_bar value=k39_bar}
C {devices/vsource.sym} -430 3220 3 0 {name=Vx40 value=x40}
C {devices/vsource.sym} -430 3240 3 0 {name=Vx40_bar value=x40_bar}
C {devices/vsource.sym} -430 3260 3 0 {name=Vk40 value=k40}
C {devices/vsource.sym} -430 3280 3 0 {name=Vk40_bar value=k40_bar}
C {devices/vsource.sym} -430 3300 3 0 {name=Vx41 value=x41}
C {devices/vsource.sym} -430 3320 3 0 {name=Vx41_bar value=x41_bar}
C {devices/vsource.sym} -430 3340 3 0 {name=Vk41 value=k41}
C {devices/vsource.sym} -430 3360 3 0 {name=Vk41_bar value=k41_bar}
C {devices/vsource.sym} -430 3380 3 0 {name=Vx42 value=x42}
C {devices/vsource.sym} -430 3400 3 0 {name=Vx42_bar value=x42_bar}
C {devices/vsource.sym} -430 3420 3 0 {name=Vk42 value=k42}
C {devices/vsource.sym} -430 3440 3 0 {name=Vk42_bar value=k42_bar}
C {devices/vsource.sym} -430 3460 3 0 {name=Vx43 value=x43}
C {devices/vsource.sym} -430 3480 3 0 {name=Vx43_bar value=x43_bar}
C {devices/vsource.sym} -430 3500 3 0 {name=Vk43 value=k43}
C {devices/vsource.sym} -430 3520 3 0 {name=Vk43_bar value=k43_bar}
C {devices/vsource.sym} -430 3540 3 0 {name=Vx44 value=x44}
C {devices/vsource.sym} -430 3560 3 0 {name=Vx44_bar value=x44_bar}
C {devices/vsource.sym} -430 3580 3 0 {name=Vk44 value=k44}
C {devices/vsource.sym} -430 3600 3 0 {name=Vk44_bar value=k44_bar}
C {devices/vsource.sym} -430 3620 3 0 {name=Vx45 value=x45}
C {devices/vsource.sym} -430 3640 3 0 {name=Vx45_bar value=x45_bar}
C {devices/vsource.sym} -430 3660 3 0 {name=Vk45 value=k45}
C {devices/vsource.sym} -430 3680 3 0 {name=Vk45_bar value=k45_bar}
C {devices/vsource.sym} -430 3700 3 0 {name=Vx46 value=x46}
C {devices/vsource.sym} -430 3720 3 0 {name=Vx46_bar value=x46_bar}
C {devices/vsource.sym} -430 3740 3 0 {name=Vk46 value=k46}
C {devices/vsource.sym} -430 3760 3 0 {name=Vk46_bar value=k46_bar}
C {devices/vsource.sym} -430 3780 3 0 {name=Vx47 value=x47}
C {devices/vsource.sym} -430 3800 3 0 {name=Vx47_bar value=x47_bar}
C {devices/vsource.sym} -430 3820 3 0 {name=Vk47 value=k47}
C {devices/vsource.sym} -430 3840 3 0 {name=Vk47_bar value=k47_bar}
C {devices/vsource.sym} -430 3860 3 0 {name=Vx48 value=x48}
C {devices/vsource.sym} -430 3880 3 0 {name=Vx48_bar value=x48_bar}
C {devices/vsource.sym} -430 3900 3 0 {name=Vk48 value=k48}
C {devices/vsource.sym} -430 3920 3 0 {name=Vk48_bar value=k48_bar}
C {devices/vsource.sym} -430 3940 3 0 {name=Vx49 value=x49}
C {devices/vsource.sym} -430 3960 3 0 {name=Vx49_bar value=x49_bar}
C {devices/vsource.sym} -430 3980 3 0 {name=Vk49 value=k49}
C {devices/vsource.sym} -430 4000 3 0 {name=Vk49_bar value=k49_bar}
C {devices/vsource.sym} -430 4020 3 0 {name=Vx50 value=x50}
C {devices/vsource.sym} -430 4040 3 0 {name=Vx50_bar value=x50_bar}
C {devices/vsource.sym} -430 4060 3 0 {name=Vk50 value=k50}
C {devices/vsource.sym} -430 4080 3 0 {name=Vk50_bar value=k50_bar}
C {devices/vsource.sym} -430 4100 3 0 {name=Vx51 value=x51}
C {devices/vsource.sym} -430 4120 3 0 {name=Vx51_bar value=x51_bar}
C {devices/vsource.sym} -430 4140 3 0 {name=Vk51 value=k51}
C {devices/vsource.sym} -430 4160 3 0 {name=Vk51_bar value=k51_bar}
C {devices/vsource.sym} -430 4180 3 0 {name=Vx52 value=x52}
C {devices/vsource.sym} -430 4200 3 0 {name=Vx52_bar value=x52_bar}
C {devices/vsource.sym} -430 4220 3 0 {name=Vk52 value=k52}
C {devices/vsource.sym} -430 4240 3 0 {name=Vk52_bar value=k52_bar}
C {devices/vsource.sym} -430 4260 3 0 {name=Vx53 value=x53}
C {devices/vsource.sym} -430 4280 3 0 {name=Vx53_bar value=x53_bar}
C {devices/vsource.sym} -430 4300 3 0 {name=Vk53 value=k53}
C {devices/vsource.sym} -430 4320 3 0 {name=Vk53_bar value=k53_bar}
C {devices/vsource.sym} -430 4340 3 0 {name=Vx54 value=x54}
C {devices/vsource.sym} -430 4360 3 0 {name=Vx54_bar value=x54_bar}
C {devices/vsource.sym} -430 4380 3 0 {name=Vk54 value=k54}
C {devices/vsource.sym} -430 4400 3 0 {name=Vk54_bar value=k54_bar}
C {devices/vsource.sym} -430 4420 3 0 {name=Vx55 value=x55}
C {devices/vsource.sym} -430 4440 3 0 {name=Vx55_bar value=x55_bar}
C {devices/vsource.sym} -430 4460 3 0 {name=Vk55 value=k55}
C {devices/vsource.sym} -430 4480 3 0 {name=Vk55_bar value=k55_bar}
C {devices/vsource.sym} -430 4500 3 0 {name=Vx56 value=x56}
C {devices/vsource.sym} -430 4520 3 0 {name=Vx56_bar value=x56_bar}
C {devices/vsource.sym} -430 4540 3 0 {name=Vk56 value=k56}
C {devices/vsource.sym} -430 4560 3 0 {name=Vk56_bar value=k56_bar}
C {devices/vsource.sym} -430 4580 3 0 {name=Vx57 value=x57}
C {devices/vsource.sym} -430 4600 3 0 {name=Vx57_bar value=x57_bar}
C {devices/vsource.sym} -430 4620 3 0 {name=Vk57 value=k57}
C {devices/vsource.sym} -430 4640 3 0 {name=Vk57_bar value=k57_bar}
C {devices/vsource.sym} -430 4660 3 0 {name=Vx58 value=x58}
C {devices/vsource.sym} -430 4680 3 0 {name=Vx58_bar value=x58_bar}
C {devices/vsource.sym} -430 4700 3 0 {name=Vk58 value=k58}
C {devices/vsource.sym} -430 4720 3 0 {name=Vk58_bar value=k58_bar}
C {devices/vsource.sym} -430 4740 3 0 {name=Vx59 value=x59}
C {devices/vsource.sym} -430 4760 3 0 {name=Vx59_bar value=x59_bar}
C {devices/vsource.sym} -430 4780 3 0 {name=Vk59 value=k59}
C {devices/vsource.sym} -430 4800 3 0 {name=Vk59_bar value=k59_bar}
C {devices/vsource.sym} -430 4820 3 0 {name=Vx60 value=x60}
C {devices/vsource.sym} -430 4840 3 0 {name=Vx60_bar value=x60_bar}
C {devices/vsource.sym} -430 4860 3 0 {name=Vk60 value=k60}
C {devices/vsource.sym} -430 4880 3 0 {name=Vk60_bar value=k60_bar}
C {devices/vsource.sym} -430 4900 3 0 {name=Vx61 value=x61}
C {devices/vsource.sym} -430 4920 3 0 {name=Vx61_bar value=x61_bar}
C {devices/vsource.sym} -430 4940 3 0 {name=Vk61 value=k61}
C {devices/vsource.sym} -430 4960 3 0 {name=Vk61_bar value=k61_bar}
C {devices/vsource.sym} -430 4980 3 0 {name=Vx62 value=x62}
C {devices/vsource.sym} -430 5000 3 0 {name=Vx62_bar value=x62_bar}
C {devices/vsource.sym} -430 5020 3 0 {name=Vk62 value=k62}
C {devices/vsource.sym} -430 5040 3 0 {name=Vk62_bar value=k62_bar}
C {devices/vsource.sym} -430 5060 3 0 {name=Vx63 value=x63}
C {devices/vsource.sym} -430 5080 3 0 {name=Vx63_bar value=x63_bar}
C {devices/vsource.sym} -430 5100 3 0 {name=Vk63 value=k63}
C {devices/vsource.sym} -430 5120 3 0 {name=Vk63_bar value=k63_bar}
C {devices/vsource.sym} -720 40 3 0 {name=Vx0 value=0}
C {devices/vsource.sym} -720 60 3 0 {name=Vx0_bar value=1.8}
C {devices/vsource.sym} -720 80 3 0 {name=Vk0 value=1.8}
C {devices/vsource.sym} -720 100 3 0 {name=Vk0_bar value=0}
C {devices/vsource.sym} -720 120 3 0 {name=Vx1 value=0}
C {devices/vsource.sym} -720 140 3 0 {name=Vx1_bar value=1.8}
C {devices/vsource.sym} -720 160 3 0 {name=Vk1 value=1.8}
C {devices/vsource.sym} -720 180 3 0 {name=Vk1_bar value=0}
C {devices/vsource.sym} -720 200 3 0 {name=Vx2 value=0}
C {devices/vsource.sym} -720 220 3 0 {name=Vx2_bar value=1.8}
C {devices/vsource.sym} -720 240 3 0 {name=Vk2 value=1.8}
C {devices/vsource.sym} -720 260 3 0 {name=Vk2_bar value=0}
C {devices/vsource.sym} -720 280 3 0 {name=Vx3 value=0}
C {devices/vsource.sym} -720 300 3 0 {name=Vx3_bar value=1.8}
C {devices/vsource.sym} -720 320 3 0 {name=Vk3 value=1.8}
C {devices/vsource.sym} -720 340 3 0 {name=Vk3_bar value=0}
C {devices/vsource.sym} -720 360 3 0 {name=Vx4 value=0}
C {devices/vsource.sym} -720 380 3 0 {name=Vx4_bar value=1.8}
C {devices/vsource.sym} -720 400 3 0 {name=Vk4 value=1.8}
C {devices/vsource.sym} -720 420 3 0 {name=Vk4_bar value=0}
C {devices/vsource.sym} -720 440 3 0 {name=Vx5 value=0}
C {devices/vsource.sym} -720 460 3 0 {name=Vx5_bar value=1.8}
C {devices/vsource.sym} -720 480 3 0 {name=Vk5 value=1.8}
C {devices/vsource.sym} -720 500 3 0 {name=Vk5_bar value=0}
C {devices/vsource.sym} -720 520 3 0 {name=Vx6 value=0}
C {devices/vsource.sym} -720 540 3 0 {name=Vx6_bar value=1.8}
C {devices/vsource.sym} -720 560 3 0 {name=Vk6 value=1.8}
C {devices/vsource.sym} -720 580 3 0 {name=Vk6_bar value=0}
C {devices/vsource.sym} -720 600 3 0 {name=Vx7 value=0}
C {devices/vsource.sym} -720 620 3 0 {name=Vx7_bar value=1.8}
C {devices/vsource.sym} -720 640 3 0 {name=Vk7 value=1.8}
C {devices/vsource.sym} -720 660 3 0 {name=Vk7_bar value=0}
C {devices/vsource.sym} -720 680 3 0 {name=Vx8 value=0}
C {devices/vsource.sym} -720 700 3 0 {name=Vx8_bar value=1.8}
C {devices/vsource.sym} -720 720 3 0 {name=Vk8 value=1.8}
C {devices/vsource.sym} -720 740 3 0 {name=Vk8_bar value=0}
C {devices/vsource.sym} -720 760 3 0 {name=Vx9 value=0}
C {devices/vsource.sym} -720 780 3 0 {name=Vx9_bar value=1.8}
C {devices/vsource.sym} -720 800 3 0 {name=Vk9 value=1.8}
C {devices/vsource.sym} -720 820 3 0 {name=Vk9_bar value=0}
C {devices/vsource.sym} -720 840 3 0 {name=Vx10 value=0}
C {devices/vsource.sym} -720 860 3 0 {name=Vx10_bar value=1.8}
C {devices/vsource.sym} -720 880 3 0 {name=Vk10 value=1.8}
C {devices/vsource.sym} -720 900 3 0 {name=Vk10_bar value=0}
C {devices/vsource.sym} -720 920 3 0 {name=Vx11 value=0}
C {devices/vsource.sym} -720 940 3 0 {name=Vx11_bar value=1.8}
C {devices/vsource.sym} -720 960 3 0 {name=Vk11 value=1.8}
C {devices/vsource.sym} -720 980 3 0 {name=Vk11_bar value=0}
C {devices/vsource.sym} -720 1000 3 0 {name=Vx12 value=0}
C {devices/vsource.sym} -720 1020 3 0 {name=Vx12_bar value=1.8}
C {devices/vsource.sym} -720 1040 3 0 {name=Vk12 value=1.8}
C {devices/vsource.sym} -720 1060 3 0 {name=Vk12_bar value=0}
C {devices/vsource.sym} -720 1080 3 0 {name=Vx13 value=0}
C {devices/vsource.sym} -720 1100 3 0 {name=Vx13_bar value=1.8}
C {devices/vsource.sym} -720 1120 3 0 {name=Vk13 value=1.8}
C {devices/vsource.sym} -720 1140 3 0 {name=Vk13_bar value=0}
C {devices/vsource.sym} -720 1160 3 0 {name=Vx14 value=0}
C {devices/vsource.sym} -720 1180 3 0 {name=Vx14_bar value=1.8}
C {devices/vsource.sym} -720 1200 3 0 {name=Vk14 value=1.8}
C {devices/vsource.sym} -720 1220 3 0 {name=Vk14_bar value=0}
C {devices/vsource.sym} -720 1240 3 0 {name=Vx15 value=0}
C {devices/vsource.sym} -720 1260 3 0 {name=Vx15_bar value=1.8}
C {devices/vsource.sym} -720 1280 3 0 {name=Vk15 value=1.8}
C {devices/vsource.sym} -720 1300 3 0 {name=Vk15_bar value=0}
C {devices/vsource.sym} -720 1320 3 0 {name=Vx16 value=0}
C {devices/vsource.sym} -720 1340 3 0 {name=Vx16_bar value=1.8}
C {devices/vsource.sym} -720 1360 3 0 {name=Vk16 value=1.8}
C {devices/vsource.sym} -720 1380 3 0 {name=Vk16_bar value=0}
C {devices/vsource.sym} -720 1400 3 0 {name=Vx17 value=0}
C {devices/vsource.sym} -720 1420 3 0 {name=Vx17_bar value=1.8}
C {devices/vsource.sym} -720 1440 3 0 {name=Vk17 value=1.8}
C {devices/vsource.sym} -720 1460 3 0 {name=Vk17_bar value=0}
C {devices/vsource.sym} -720 1480 3 0 {name=Vx18 value=0}
C {devices/vsource.sym} -720 1500 3 0 {name=Vx18_bar value=1.8}
C {devices/vsource.sym} -720 1520 3 0 {name=Vk18 value=1.8}
C {devices/vsource.sym} -720 1540 3 0 {name=Vk18_bar value=0}
C {devices/vsource.sym} -720 1560 3 0 {name=Vx19 value=0}
C {devices/vsource.sym} -720 1580 3 0 {name=Vx19_bar value=1.8}
C {devices/vsource.sym} -720 1600 3 0 {name=Vk19 value=1.8}
C {devices/vsource.sym} -720 1620 3 0 {name=Vk19_bar value=0}
C {devices/vsource.sym} -720 1640 3 0 {name=Vx20 value=0}
C {devices/vsource.sym} -720 1660 3 0 {name=Vx20_bar value=1.8}
C {devices/vsource.sym} -720 1680 3 0 {name=Vk20 value=1.8}
C {devices/vsource.sym} -720 1700 3 0 {name=Vk20_bar value=0}
C {devices/vsource.sym} -720 1720 3 0 {name=Vx21 value=0}
C {devices/vsource.sym} -720 1740 3 0 {name=Vx21_bar value=1.8}
C {devices/vsource.sym} -720 1760 3 0 {name=Vk21 value=1.8}
C {devices/vsource.sym} -720 1780 3 0 {name=Vk21_bar value=0}
C {devices/vsource.sym} -720 1800 3 0 {name=Vx22 value=0}
C {devices/vsource.sym} -720 1820 3 0 {name=Vx22_bar value=1.8}
C {devices/vsource.sym} -720 1840 3 0 {name=Vk22 value=1.8}
C {devices/vsource.sym} -720 1860 3 0 {name=Vk22_bar value=0}
C {devices/vsource.sym} -720 1880 3 0 {name=Vx23 value=0}
C {devices/vsource.sym} -720 1900 3 0 {name=Vx23_bar value=1.8}
C {devices/vsource.sym} -720 1920 3 0 {name=Vk23 value=1.8}
C {devices/vsource.sym} -720 1940 3 0 {name=Vk23_bar value=0}
C {devices/vsource.sym} -720 1960 3 0 {name=Vx24 value=0}
C {devices/vsource.sym} -720 1980 3 0 {name=Vx24_bar value=1.8}
C {devices/vsource.sym} -720 2000 3 0 {name=Vk24 value=1.8}
C {devices/vsource.sym} -720 2020 3 0 {name=Vk24_bar value=0}
C {devices/vsource.sym} -720 2040 3 0 {name=Vx25 value=0}
C {devices/vsource.sym} -720 2060 3 0 {name=Vx25_bar value=1.8}
C {devices/vsource.sym} -720 2080 3 0 {name=Vk25 value=1.8}
C {devices/vsource.sym} -720 2100 3 0 {name=Vk25_bar value=0}
C {devices/vsource.sym} -720 2120 3 0 {name=Vx26 value=0}
C {devices/vsource.sym} -720 2140 3 0 {name=Vx26_bar value=1.8}
C {devices/vsource.sym} -720 2160 3 0 {name=Vk26 value=1.8}
C {devices/vsource.sym} -720 2180 3 0 {name=Vk26_bar value=0}
C {devices/vsource.sym} -720 2200 3 0 {name=Vx27 value=0}
C {devices/vsource.sym} -720 2220 3 0 {name=Vx27_bar value=1.8}
C {devices/vsource.sym} -720 2240 3 0 {name=Vk27 value=1.8}
C {devices/vsource.sym} -720 2260 3 0 {name=Vk27_bar value=0}
C {devices/vsource.sym} -720 2280 3 0 {name=Vx28 value=0}
C {devices/vsource.sym} -720 2300 3 0 {name=Vx28_bar value=1.8}
C {devices/vsource.sym} -720 2320 3 0 {name=Vk28 value=1.8}
C {devices/vsource.sym} -720 2340 3 0 {name=Vk28_bar value=0}
C {devices/vsource.sym} -720 2360 3 0 {name=Vx29 value=0}
C {devices/vsource.sym} -720 2380 3 0 {name=Vx29_bar value=1.8}
C {devices/vsource.sym} -720 2400 3 0 {name=Vk29 value=1.8}
C {devices/vsource.sym} -720 2420 3 0 {name=Vk29_bar value=0}
C {devices/vsource.sym} -720 2440 3 0 {name=Vx30 value=0}
C {devices/vsource.sym} -720 2460 3 0 {name=Vx30_bar value=1.8}
C {devices/vsource.sym} -720 2480 3 0 {name=Vk30 value=1.8}
C {devices/vsource.sym} -720 2500 3 0 {name=Vk30_bar value=0}
C {devices/vsource.sym} -720 2520 3 0 {name=Vx31 value=0}
C {devices/vsource.sym} -720 2540 3 0 {name=Vx31_bar value=1.8}
C {devices/vsource.sym} -720 2560 3 0 {name=Vk31 value=1.8}
C {devices/vsource.sym} -720 2580 3 0 {name=Vk31_bar value=0}
C {devices/vsource.sym} -720 2600 3 0 {name=Vx32 value=0}
C {devices/vsource.sym} -720 2620 3 0 {name=Vx32_bar value=1.8}
C {devices/vsource.sym} -720 2640 3 0 {name=Vk32 value=1.8}
C {devices/vsource.sym} -720 2660 3 0 {name=Vk32_bar value=0}
C {devices/vsource.sym} -720 2680 3 0 {name=Vx33 value=0}
C {devices/vsource.sym} -720 2700 3 0 {name=Vx33_bar value=1.8}
C {devices/vsource.sym} -720 2720 3 0 {name=Vk33 value=1.8}
C {devices/vsource.sym} -720 2740 3 0 {name=Vk33_bar value=0}
C {devices/vsource.sym} -720 2760 3 0 {name=Vx34 value=0}
C {devices/vsource.sym} -720 2780 3 0 {name=Vx34_bar value=1.8}
C {devices/vsource.sym} -720 2800 3 0 {name=Vk34 value=1.8}
C {devices/vsource.sym} -720 2820 3 0 {name=Vk34_bar value=0}
C {devices/vsource.sym} -720 2840 3 0 {name=Vx35 value=0}
C {devices/vsource.sym} -720 2860 3 0 {name=Vx35_bar value=1.8}
C {devices/vsource.sym} -720 2880 3 0 {name=Vk35 value=1.8}
C {devices/vsource.sym} -720 2900 3 0 {name=Vk35_bar value=0}
C {devices/vsource.sym} -720 2920 3 0 {name=Vx36 value=0}
C {devices/vsource.sym} -720 2940 3 0 {name=Vx36_bar value=1.8}
C {devices/vsource.sym} -720 2960 3 0 {name=Vk36 value=1.8}
C {devices/vsource.sym} -720 2980 3 0 {name=Vk36_bar value=0}
C {devices/vsource.sym} -720 3000 3 0 {name=Vx37 value=0}
C {devices/vsource.sym} -720 3020 3 0 {name=Vx37_bar value=1.8}
C {devices/vsource.sym} -720 3040 3 0 {name=Vk37 value=1.8}
C {devices/vsource.sym} -720 3060 3 0 {name=Vk37_bar value=0}
C {devices/vsource.sym} -720 3080 3 0 {name=Vx38 value=0}
C {devices/vsource.sym} -720 3100 3 0 {name=Vx38_bar value=1.8}
C {devices/vsource.sym} -720 3120 3 0 {name=Vk38 value=1.8}
C {devices/vsource.sym} -720 3140 3 0 {name=Vk38_bar value=0}
C {devices/vsource.sym} -720 3160 3 0 {name=Vx39 value=0}
C {devices/vsource.sym} -720 3180 3 0 {name=Vx39_bar value=1.8}
C {devices/vsource.sym} -720 3200 3 0 {name=Vk39 value=1.8}
C {devices/vsource.sym} -720 3220 3 0 {name=Vk39_bar value=0}
C {devices/vsource.sym} -720 3240 3 0 {name=Vx40 value=0}
C {devices/vsource.sym} -720 3260 3 0 {name=Vx40_bar value=1.8}
C {devices/vsource.sym} -720 3280 3 0 {name=Vk40 value=1.8}
C {devices/vsource.sym} -720 3300 3 0 {name=Vk40_bar value=0}
C {devices/vsource.sym} -720 3320 3 0 {name=Vx41 value=0}
C {devices/vsource.sym} -720 3340 3 0 {name=Vx41_bar value=1.8}
C {devices/vsource.sym} -720 3360 3 0 {name=Vk41 value=1.8}
C {devices/vsource.sym} -720 3380 3 0 {name=Vk41_bar value=0}
C {devices/vsource.sym} -720 3400 3 0 {name=Vx42 value=0}
C {devices/vsource.sym} -720 3420 3 0 {name=Vx42_bar value=1.8}
C {devices/vsource.sym} -720 3440 3 0 {name=Vk42 value=1.8}
C {devices/vsource.sym} -720 3460 3 0 {name=Vk42_bar value=0}
C {devices/vsource.sym} -720 3480 3 0 {name=Vx43 value=0}
C {devices/vsource.sym} -720 3500 3 0 {name=Vx43_bar value=1.8}
C {devices/vsource.sym} -720 3520 3 0 {name=Vk43 value=1.8}
C {devices/vsource.sym} -720 3540 3 0 {name=Vk43_bar value=0}
C {devices/vsource.sym} -720 3560 3 0 {name=Vx44 value=0}
C {devices/vsource.sym} -720 3580 3 0 {name=Vx44_bar value=1.8}
C {devices/vsource.sym} -720 3600 3 0 {name=Vk44 value=1.8}
C {devices/vsource.sym} -720 3620 3 0 {name=Vk44_bar value=0}
C {devices/vsource.sym} -720 3640 3 0 {name=Vx45 value=0}
C {devices/vsource.sym} -720 3660 3 0 {name=Vx45_bar value=1.8}
C {devices/vsource.sym} -720 3680 3 0 {name=Vk45 value=1.8}
C {devices/vsource.sym} -720 3700 3 0 {name=Vk45_bar value=0}
C {devices/vsource.sym} -720 3720 3 0 {name=Vx46 value=0}
C {devices/vsource.sym} -720 3740 3 0 {name=Vx46_bar value=1.8}
C {devices/vsource.sym} -720 3760 3 0 {name=Vk46 value=1.8}
C {devices/vsource.sym} -720 3780 3 0 {name=Vk46_bar value=0}
C {devices/vsource.sym} -720 3800 3 0 {name=Vx47 value=0}
C {devices/vsource.sym} -720 3820 3 0 {name=Vx47_bar value=1.8}
C {devices/vsource.sym} -720 3840 3 0 {name=Vk47 value=1.8}
C {devices/vsource.sym} -720 3860 3 0 {name=Vk47_bar value=0}
C {devices/vsource.sym} -720 3880 3 0 {name=Vx48 value=0}
C {devices/vsource.sym} -720 3900 3 0 {name=Vx48_bar value=1.8}
C {devices/vsource.sym} -720 3920 3 0 {name=Vk48 value=1.8}
C {devices/vsource.sym} -720 3940 3 0 {name=Vk48_bar value=0}
C {devices/vsource.sym} -720 3960 3 0 {name=Vx49 value=0}
C {devices/vsource.sym} -720 3980 3 0 {name=Vx49_bar value=1.8}
C {devices/vsource.sym} -720 4000 3 0 {name=Vk49 value=1.8}
C {devices/vsource.sym} -720 4020 3 0 {name=Vk49_bar value=0}
C {devices/vsource.sym} -720 4040 3 0 {name=Vx50 value=0}
C {devices/vsource.sym} -720 4060 3 0 {name=Vx50_bar value=1.8}
C {devices/vsource.sym} -720 4080 3 0 {name=Vk50 value=1.8}
C {devices/vsource.sym} -720 4100 3 0 {name=Vk50_bar value=0}
C {devices/vsource.sym} -720 4120 3 0 {name=Vx51 value=0}
C {devices/vsource.sym} -720 4140 3 0 {name=Vx51_bar value=1.8}
C {devices/vsource.sym} -720 4160 3 0 {name=Vk51 value=1.8}
C {devices/vsource.sym} -720 4180 3 0 {name=Vk51_bar value=0}
C {devices/vsource.sym} -720 4200 3 0 {name=Vx52 value=0}
C {devices/vsource.sym} -720 4220 3 0 {name=Vx52_bar value=1.8}
C {devices/vsource.sym} -720 4240 3 0 {name=Vk52 value=1.8}
C {devices/vsource.sym} -720 4260 3 0 {name=Vk52_bar value=0}
C {devices/vsource.sym} -720 4280 3 0 {name=Vx53 value=0}
C {devices/vsource.sym} -720 4300 3 0 {name=Vx53_bar value=1.8}
C {devices/vsource.sym} -720 4320 3 0 {name=Vk53 value=1.8}
C {devices/vsource.sym} -720 4340 3 0 {name=Vk53_bar value=0}
C {devices/vsource.sym} -720 4360 3 0 {name=Vx54 value=0}
C {devices/vsource.sym} -720 4380 3 0 {name=Vx54_bar value=1.8}
C {devices/vsource.sym} -720 4400 3 0 {name=Vk54 value=1.8}
C {devices/vsource.sym} -720 4420 3 0 {name=Vk54_bar value=0}
C {devices/vsource.sym} -720 4440 3 0 {name=Vx55 value=0}
C {devices/vsource.sym} -720 4460 3 0 {name=Vx55_bar value=1.8}
C {devices/vsource.sym} -720 4480 3 0 {name=Vk55 value=1.8}
C {devices/vsource.sym} -720 4500 3 0 {name=Vk55_bar value=0}
C {devices/vsource.sym} -720 4520 3 0 {name=Vx56 value=0}
C {devices/vsource.sym} -720 4540 3 0 {name=Vx56_bar value=1.8}
C {devices/vsource.sym} -720 4560 3 0 {name=Vk56 value=1.8}
C {devices/vsource.sym} -720 4580 3 0 {name=Vk56_bar value=0}
C {devices/vsource.sym} -720 4600 3 0 {name=Vx57 value=0}
C {devices/vsource.sym} -720 4620 3 0 {name=Vx57_bar value=1.8}
C {devices/vsource.sym} -720 4640 3 0 {name=Vk57 value=1.8}
C {devices/vsource.sym} -720 4660 3 0 {name=Vk57_bar value=0}
C {devices/vsource.sym} -720 4680 3 0 {name=Vx58 value=0}
C {devices/vsource.sym} -720 4700 3 0 {name=Vx58_bar value=1.8}
C {devices/vsource.sym} -720 4720 3 0 {name=Vk58 value=1.8}
C {devices/vsource.sym} -720 4740 3 0 {name=Vk58_bar value=0}
C {devices/vsource.sym} -720 4760 3 0 {name=Vx59 value=0}
C {devices/vsource.sym} -720 4780 3 0 {name=Vx59_bar value=1.8}
C {devices/vsource.sym} -720 4800 3 0 {name=Vk59 value=1.8}
C {devices/vsource.sym} -720 4820 3 0 {name=Vk59_bar value=0}
C {devices/vsource.sym} -720 4840 3 0 {name=Vx60 value=0}
C {devices/vsource.sym} -720 4860 3 0 {name=Vx60_bar value=1.8}
C {devices/vsource.sym} -720 4880 3 0 {name=Vk60 value=1.8}
C {devices/vsource.sym} -720 4900 3 0 {name=Vk60_bar value=0}
C {devices/vsource.sym} -720 4920 3 0 {name=Vx61 value=0}
C {devices/vsource.sym} -720 4940 3 0 {name=Vx61_bar value=1.8}
C {devices/vsource.sym} -720 4960 3 0 {name=Vk61 value=1.8}
C {devices/vsource.sym} -720 4980 3 0 {name=Vk61_bar value=0}
C {devices/vsource.sym} -720 5000 3 0 {name=Vx62 value=0}
C {devices/vsource.sym} -720 5020 3 0 {name=Vx62_bar value=1.8}
C {devices/vsource.sym} -720 5040 3 0 {name=Vk62 value=1.8}
C {devices/vsource.sym} -720 5060 3 0 {name=Vk62_bar value=0}
C {devices/vsource.sym} -720 5080 3 0 {name=Vx63 value=0}
C {devices/vsource.sym} -720 5100 3 0 {name=Vx63_bar value=1.8}
C {devices/vsource.sym} -720 5120 3 0 {name=Vk63 value=1.8}
C {devices/vsource.sym} -720 5140 3 0 {name=Vk63_bar value=0}
C {devices/ipin.sym} -110 0 0 0 {name=p0x lab=x0}
C {devices/ipin.sym} -110 20 0 0 {name=p0x_bar lab=x0_bar}
C {devices/ipin.sym} -110 40 0 0 {name=p0k lab=k0}
C {devices/ipin.sym} -110 60 0 0 {name=p0k_bar lab=k0_bar}
C {devices/ipin.sym} -110 80 0 0 {name=p1x lab=x1}
C {devices/ipin.sym} -110 100 0 0 {name=p1x_bar lab=x1_bar}
C {devices/ipin.sym} -110 120 0 0 {name=p1k lab=k1}
C {devices/ipin.sym} -110 140 0 0 {name=p1k_bar lab=k1_bar}
C {devices/ipin.sym} -110 160 0 0 {name=p2x lab=x2}
C {devices/ipin.sym} -110 180 0 0 {name=p2x_bar lab=x2_bar}
C {devices/ipin.sym} -110 200 0 0 {name=p2k lab=k2}
C {devices/ipin.sym} -110 220 0 0 {name=p2k_bar lab=k2_bar}
C {devices/ipin.sym} -110 240 0 0 {name=p3x lab=x3}
C {devices/ipin.sym} -110 260 0 0 {name=p3x_bar lab=x3_bar}
C {devices/ipin.sym} -110 280 0 0 {name=p3k lab=k3}
C {devices/ipin.sym} -110 300 0 0 {name=p3k_bar lab=k3_bar}
C {devices/ipin.sym} -110 320 0 0 {name=p4x lab=x4}
C {devices/ipin.sym} -110 340 0 0 {name=p4x_bar lab=x4_bar}
C {devices/ipin.sym} -110 360 0 0 {name=p4k lab=k4}
C {devices/ipin.sym} -110 380 0 0 {name=p4k_bar lab=k4_bar}
C {devices/ipin.sym} -110 400 0 0 {name=p5x lab=x5}
C {devices/ipin.sym} -110 420 0 0 {name=p5x_bar lab=x5_bar}
C {devices/ipin.sym} -110 440 0 0 {name=p5k lab=k5}
C {devices/ipin.sym} -110 460 0 0 {name=p5k_bar lab=k5_bar}
C {devices/ipin.sym} -110 480 0 0 {name=p6x lab=x6}
C {devices/ipin.sym} -110 500 0 0 {name=p6x_bar lab=x6_bar}
C {devices/ipin.sym} -110 520 0 0 {name=p6k lab=k6}
C {devices/ipin.sym} -110 540 0 0 {name=p6k_bar lab=k6_bar}
C {devices/ipin.sym} -110 560 0 0 {name=p7x lab=x7}
C {devices/ipin.sym} -110 580 0 0 {name=p7x_bar lab=x7_bar}
C {devices/ipin.sym} -110 600 0 0 {name=p7k lab=k7}
C {devices/ipin.sym} -110 620 0 0 {name=p7k_bar lab=k7_bar}
C {devices/ipin.sym} -110 640 0 0 {name=p8x lab=x8}
C {devices/ipin.sym} -110 660 0 0 {name=p8x_bar lab=x8_bar}
C {devices/ipin.sym} -110 680 0 0 {name=p8k lab=k8}
C {devices/ipin.sym} -110 700 0 0 {name=p8k_bar lab=k8_bar}
C {devices/ipin.sym} -110 720 0 0 {name=p9x lab=x9}
C {devices/ipin.sym} -110 740 0 0 {name=p9x_bar lab=x9_bar}
C {devices/ipin.sym} -110 760 0 0 {name=p9k lab=k9}
C {devices/ipin.sym} -110 780 0 0 {name=p9k_bar lab=k9_bar}
C {devices/ipin.sym} -110 800 0 0 {name=p10x lab=x10}
C {devices/ipin.sym} -110 820 0 0 {name=p10x_bar lab=x10_bar}
C {devices/ipin.sym} -110 840 0 0 {name=p10k lab=k10}
C {devices/ipin.sym} -110 860 0 0 {name=p10k_bar lab=k10_bar}
C {devices/ipin.sym} -110 880 0 0 {name=p11x lab=x11}
C {devices/ipin.sym} -110 900 0 0 {name=p11x_bar lab=x11_bar}
C {devices/ipin.sym} -110 920 0 0 {name=p11k lab=k11}
C {devices/ipin.sym} -110 940 0 0 {name=p11k_bar lab=k11_bar}
C {devices/ipin.sym} -110 960 0 0 {name=p12x lab=x12}
C {devices/ipin.sym} -110 980 0 0 {name=p12x_bar lab=x12_bar}
C {devices/ipin.sym} -110 1000 0 0 {name=p12k lab=k12}
C {devices/ipin.sym} -110 1020 0 0 {name=p12k_bar lab=k12_bar}
C {devices/ipin.sym} -110 1040 0 0 {name=p13x lab=x13}
C {devices/ipin.sym} -110 1060 0 0 {name=p13x_bar lab=x13_bar}
C {devices/ipin.sym} -110 1080 0 0 {name=p13k lab=k13}
C {devices/ipin.sym} -110 1100 0 0 {name=p13k_bar lab=k13_bar}
C {devices/ipin.sym} -110 1120 0 0 {name=p14x lab=x14}
C {devices/ipin.sym} -110 1140 0 0 {name=p14x_bar lab=x14_bar}
C {devices/ipin.sym} -110 1160 0 0 {name=p14k lab=k14}
C {devices/ipin.sym} -110 1180 0 0 {name=p14k_bar lab=k14_bar}
C {devices/ipin.sym} -110 1200 0 0 {name=p15x lab=x15}
C {devices/ipin.sym} -110 1220 0 0 {name=p15x_bar lab=x15_bar}
C {devices/ipin.sym} -110 1240 0 0 {name=p15k lab=k15}
C {devices/ipin.sym} -110 1260 0 0 {name=p15k_bar lab=k15_bar}
C {devices/ipin.sym} -110 1280 0 0 {name=p16x lab=x16}
C {devices/ipin.sym} -110 1300 0 0 {name=p16x_bar lab=x16_bar}
C {devices/ipin.sym} -110 1320 0 0 {name=p16k lab=k16}
C {devices/ipin.sym} -110 1340 0 0 {name=p16k_bar lab=k16_bar}
C {devices/ipin.sym} -110 1360 0 0 {name=p17x lab=x17}
C {devices/ipin.sym} -110 1380 0 0 {name=p17x_bar lab=x17_bar}
C {devices/ipin.sym} -110 1400 0 0 {name=p17k lab=k17}
C {devices/ipin.sym} -110 1420 0 0 {name=p17k_bar lab=k17_bar}
C {devices/ipin.sym} -110 1440 0 0 {name=p18x lab=x18}
C {devices/ipin.sym} -110 1460 0 0 {name=p18x_bar lab=x18_bar}
C {devices/ipin.sym} -110 1480 0 0 {name=p18k lab=k18}
C {devices/ipin.sym} -110 1500 0 0 {name=p18k_bar lab=k18_bar}
C {devices/ipin.sym} -110 1520 0 0 {name=p19x lab=x19}
C {devices/ipin.sym} -110 1540 0 0 {name=p19x_bar lab=x19_bar}
C {devices/ipin.sym} -110 1560 0 0 {name=p19k lab=k19}
C {devices/ipin.sym} -110 1580 0 0 {name=p19k_bar lab=k19_bar}
C {devices/ipin.sym} -110 1600 0 0 {name=p20x lab=x20}
C {devices/ipin.sym} -110 1620 0 0 {name=p20x_bar lab=x20_bar}
C {devices/ipin.sym} -110 1640 0 0 {name=p20k lab=k20}
C {devices/ipin.sym} -110 1660 0 0 {name=p20k_bar lab=k20_bar}
C {devices/ipin.sym} -110 1680 0 0 {name=p21x lab=x21}
C {devices/ipin.sym} -110 1700 0 0 {name=p21x_bar lab=x21_bar}
C {devices/ipin.sym} -110 1720 0 0 {name=p21k lab=k21}
C {devices/ipin.sym} -110 1740 0 0 {name=p21k_bar lab=k21_bar}
C {devices/ipin.sym} -110 1760 0 0 {name=p22x lab=x22}
C {devices/ipin.sym} -110 1780 0 0 {name=p22x_bar lab=x22_bar}
C {devices/ipin.sym} -110 1800 0 0 {name=p22k lab=k22}
C {devices/ipin.sym} -110 1820 0 0 {name=p22k_bar lab=k22_bar}
C {devices/ipin.sym} -110 1840 0 0 {name=p23x lab=x23}
C {devices/ipin.sym} -110 1860 0 0 {name=p23x_bar lab=x23_bar}
C {devices/ipin.sym} -110 1880 0 0 {name=p23k lab=k23}
C {devices/ipin.sym} -110 1900 0 0 {name=p23k_bar lab=k23_bar}
C {devices/ipin.sym} -110 1920 0 0 {name=p24x lab=x24}
C {devices/ipin.sym} -110 1940 0 0 {name=p24x_bar lab=x24_bar}
C {devices/ipin.sym} -110 1960 0 0 {name=p24k lab=k24}
C {devices/ipin.sym} -110 1980 0 0 {name=p24k_bar lab=k24_bar}
C {devices/ipin.sym} -110 2000 0 0 {name=p25x lab=x25}
C {devices/ipin.sym} -110 2020 0 0 {name=p25x_bar lab=x25_bar}
C {devices/ipin.sym} -110 2040 0 0 {name=p25k lab=k25}
C {devices/ipin.sym} -110 2060 0 0 {name=p25k_bar lab=k25_bar}
C {devices/ipin.sym} -110 2080 0 0 {name=p26x lab=x26}
C {devices/ipin.sym} -110 2100 0 0 {name=p26x_bar lab=x26_bar}
C {devices/ipin.sym} -110 2120 0 0 {name=p26k lab=k26}
C {devices/ipin.sym} -110 2140 0 0 {name=p26k_bar lab=k26_bar}
C {devices/ipin.sym} -110 2160 0 0 {name=p27x lab=x27}
C {devices/ipin.sym} -110 2180 0 0 {name=p27x_bar lab=x27_bar}
C {devices/ipin.sym} -110 2200 0 0 {name=p27k lab=k27}
C {devices/ipin.sym} -110 2220 0 0 {name=p27k_bar lab=k27_bar}
C {devices/ipin.sym} -110 2240 0 0 {name=p28x lab=x28}
C {devices/ipin.sym} -110 2260 0 0 {name=p28x_bar lab=x28_bar}
C {devices/ipin.sym} -110 2280 0 0 {name=p28k lab=k28}
C {devices/ipin.sym} -110 2300 0 0 {name=p28k_bar lab=k28_bar}
C {devices/ipin.sym} -110 2320 0 0 {name=p29x lab=x29}
C {devices/ipin.sym} -110 2340 0 0 {name=p29x_bar lab=x29_bar}
C {devices/ipin.sym} -110 2360 0 0 {name=p29k lab=k29}
C {devices/ipin.sym} -110 2380 0 0 {name=p29k_bar lab=k29_bar}
C {devices/ipin.sym} -110 2400 0 0 {name=p30x lab=x30}
C {devices/ipin.sym} -110 2420 0 0 {name=p30x_bar lab=x30_bar}
C {devices/ipin.sym} -110 2440 0 0 {name=p30k lab=k30}
C {devices/ipin.sym} -110 2460 0 0 {name=p30k_bar lab=k30_bar}
C {devices/ipin.sym} -110 2480 0 0 {name=p31x lab=x31}
C {devices/ipin.sym} -110 2500 0 0 {name=p31x_bar lab=x31_bar}
C {devices/ipin.sym} -110 2520 0 0 {name=p31k lab=k31}
C {devices/ipin.sym} -110 2540 0 0 {name=p31k_bar lab=k31_bar}
C {devices/ipin.sym} -110 2560 0 0 {name=p32x lab=x32}
C {devices/ipin.sym} -110 2580 0 0 {name=p32x_bar lab=x32_bar}
C {devices/ipin.sym} -110 2600 0 0 {name=p32k lab=k32}
C {devices/ipin.sym} -110 2620 0 0 {name=p32k_bar lab=k32_bar}
C {devices/ipin.sym} -110 2640 0 0 {name=p33x lab=x33}
C {devices/ipin.sym} -110 2660 0 0 {name=p33x_bar lab=x33_bar}
C {devices/ipin.sym} -110 2680 0 0 {name=p33k lab=k33}
C {devices/ipin.sym} -110 2700 0 0 {name=p33k_bar lab=k33_bar}
C {devices/ipin.sym} -110 2720 0 0 {name=p34x lab=x34}
C {devices/ipin.sym} -110 2740 0 0 {name=p34x_bar lab=x34_bar}
C {devices/ipin.sym} -110 2760 0 0 {name=p34k lab=k34}
C {devices/ipin.sym} -110 2780 0 0 {name=p34k_bar lab=k34_bar}
C {devices/ipin.sym} -110 2800 0 0 {name=p35x lab=x35}
C {devices/ipin.sym} -110 2820 0 0 {name=p35x_bar lab=x35_bar}
C {devices/ipin.sym} -110 2840 0 0 {name=p35k lab=k35}
C {devices/ipin.sym} -110 2860 0 0 {name=p35k_bar lab=k35_bar}
C {devices/ipin.sym} -110 2880 0 0 {name=p36x lab=x36}
C {devices/ipin.sym} -110 2900 0 0 {name=p36x_bar lab=x36_bar}
C {devices/ipin.sym} -110 2920 0 0 {name=p36k lab=k36}
C {devices/ipin.sym} -110 2940 0 0 {name=p36k_bar lab=k36_bar}
C {devices/ipin.sym} -110 2960 0 0 {name=p37x lab=x37}
C {devices/ipin.sym} -110 2980 0 0 {name=p37x_bar lab=x37_bar}
C {devices/ipin.sym} -110 3000 0 0 {name=p37k lab=k37}
C {devices/ipin.sym} -110 3020 0 0 {name=p37k_bar lab=k37_bar}
C {devices/ipin.sym} -110 3040 0 0 {name=p38x lab=x38}
C {devices/ipin.sym} -110 3060 0 0 {name=p38x_bar lab=x38_bar}
C {devices/ipin.sym} -110 3080 0 0 {name=p38k lab=k38}
C {devices/ipin.sym} -110 3100 0 0 {name=p38k_bar lab=k38_bar}
C {devices/ipin.sym} -110 3120 0 0 {name=p39x lab=x39}
C {devices/ipin.sym} -110 3140 0 0 {name=p39x_bar lab=x39_bar}
C {devices/ipin.sym} -110 3160 0 0 {name=p39k lab=k39}
C {devices/ipin.sym} -110 3180 0 0 {name=p39k_bar lab=k39_bar}
C {devices/ipin.sym} -110 3200 0 0 {name=p40x lab=x40}
C {devices/ipin.sym} -110 3220 0 0 {name=p40x_bar lab=x40_bar}
C {devices/ipin.sym} -110 3240 0 0 {name=p40k lab=k40}
C {devices/ipin.sym} -110 3260 0 0 {name=p40k_bar lab=k40_bar}
C {devices/ipin.sym} -110 3280 0 0 {name=p41x lab=x41}
C {devices/ipin.sym} -110 3300 0 0 {name=p41x_bar lab=x41_bar}
C {devices/ipin.sym} -110 3320 0 0 {name=p41k lab=k41}
C {devices/ipin.sym} -110 3340 0 0 {name=p41k_bar lab=k41_bar}
C {devices/ipin.sym} -110 3360 0 0 {name=p42x lab=x42}
C {devices/ipin.sym} -110 3380 0 0 {name=p42x_bar lab=x42_bar}
C {devices/ipin.sym} -110 3400 0 0 {name=p42k lab=k42}
C {devices/ipin.sym} -110 3420 0 0 {name=p42k_bar lab=k42_bar}
C {devices/ipin.sym} -110 3440 0 0 {name=p43x lab=x43}
C {devices/ipin.sym} -110 3460 0 0 {name=p43x_bar lab=x43_bar}
C {devices/ipin.sym} -110 3480 0 0 {name=p43k lab=k43}
C {devices/ipin.sym} -110 3500 0 0 {name=p43k_bar lab=k43_bar}
C {devices/ipin.sym} -110 3520 0 0 {name=p44x lab=x44}
C {devices/ipin.sym} -110 3540 0 0 {name=p44x_bar lab=x44_bar}
C {devices/ipin.sym} -110 3560 0 0 {name=p44k lab=k44}
C {devices/ipin.sym} -110 3580 0 0 {name=p44k_bar lab=k44_bar}
C {devices/ipin.sym} -110 3600 0 0 {name=p45x lab=x45}
C {devices/ipin.sym} -110 3620 0 0 {name=p45x_bar lab=x45_bar}
C {devices/ipin.sym} -110 3640 0 0 {name=p45k lab=k45}
C {devices/ipin.sym} -110 3660 0 0 {name=p45k_bar lab=k45_bar}
C {devices/ipin.sym} -110 3680 0 0 {name=p46x lab=x46}
C {devices/ipin.sym} -110 3700 0 0 {name=p46x_bar lab=x46_bar}
C {devices/ipin.sym} -110 3720 0 0 {name=p46k lab=k46}
C {devices/ipin.sym} -110 3740 0 0 {name=p46k_bar lab=k46_bar}
C {devices/ipin.sym} -110 3760 0 0 {name=p47x lab=x47}
C {devices/ipin.sym} -110 3780 0 0 {name=p47x_bar lab=x47_bar}
C {devices/ipin.sym} -110 3800 0 0 {name=p47k lab=k47}
C {devices/ipin.sym} -110 3820 0 0 {name=p47k_bar lab=k47_bar}
C {devices/ipin.sym} -110 3840 0 0 {name=p48x lab=x48}
C {devices/ipin.sym} -110 3860 0 0 {name=p48x_bar lab=x48_bar}
C {devices/ipin.sym} -110 3880 0 0 {name=p48k lab=k48}
C {devices/ipin.sym} -110 3900 0 0 {name=p48k_bar lab=k48_bar}
C {devices/ipin.sym} -110 3920 0 0 {name=p49x lab=x49}
C {devices/ipin.sym} -110 3940 0 0 {name=p49x_bar lab=x49_bar}
C {devices/ipin.sym} -110 3960 0 0 {name=p49k lab=k49}
C {devices/ipin.sym} -110 3980 0 0 {name=p49k_bar lab=k49_bar}
C {devices/ipin.sym} -110 4000 0 0 {name=p50x lab=x50}
C {devices/ipin.sym} -110 4020 0 0 {name=p50x_bar lab=x50_bar}
C {devices/ipin.sym} -110 4040 0 0 {name=p50k lab=k50}
C {devices/ipin.sym} -110 4060 0 0 {name=p50k_bar lab=k50_bar}
C {devices/ipin.sym} -110 4080 0 0 {name=p51x lab=x51}
C {devices/ipin.sym} -110 4100 0 0 {name=p51x_bar lab=x51_bar}
C {devices/ipin.sym} -110 4120 0 0 {name=p51k lab=k51}
C {devices/ipin.sym} -110 4140 0 0 {name=p51k_bar lab=k51_bar}
C {devices/ipin.sym} -110 4160 0 0 {name=p52x lab=x52}
C {devices/ipin.sym} -110 4180 0 0 {name=p52x_bar lab=x52_bar}
C {devices/ipin.sym} -110 4200 0 0 {name=p52k lab=k52}
C {devices/ipin.sym} -110 4220 0 0 {name=p52k_bar lab=k52_bar}
C {devices/ipin.sym} -110 4240 0 0 {name=p53x lab=x53}
C {devices/ipin.sym} -110 4260 0 0 {name=p53x_bar lab=x53_bar}
C {devices/ipin.sym} -110 4280 0 0 {name=p53k lab=k53}
C {devices/ipin.sym} -110 4300 0 0 {name=p53k_bar lab=k53_bar}
C {devices/ipin.sym} -110 4320 0 0 {name=p54x lab=x54}
C {devices/ipin.sym} -110 4340 0 0 {name=p54x_bar lab=x54_bar}
C {devices/ipin.sym} -110 4360 0 0 {name=p54k lab=k54}
C {devices/ipin.sym} -110 4380 0 0 {name=p54k_bar lab=k54_bar}
C {devices/ipin.sym} -110 4400 0 0 {name=p55x lab=x55}
C {devices/ipin.sym} -110 4420 0 0 {name=p55x_bar lab=x55_bar}
C {devices/ipin.sym} -110 4440 0 0 {name=p55k lab=k55}
C {devices/ipin.sym} -110 4460 0 0 {name=p55k_bar lab=k55_bar}
C {devices/ipin.sym} -110 4480 0 0 {name=p56x lab=x56}
C {devices/ipin.sym} -110 4500 0 0 {name=p56x_bar lab=x56_bar}
C {devices/ipin.sym} -110 4520 0 0 {name=p56k lab=k56}
C {devices/ipin.sym} -110 4540 0 0 {name=p56k_bar lab=k56_bar}
C {devices/ipin.sym} -110 4560 0 0 {name=p57x lab=x57}
C {devices/ipin.sym} -110 4580 0 0 {name=p57x_bar lab=x57_bar}
C {devices/ipin.sym} -110 4600 0 0 {name=p57k lab=k57}
C {devices/ipin.sym} -110 4620 0 0 {name=p57k_bar lab=k57_bar}
C {devices/ipin.sym} -110 4640 0 0 {name=p58x lab=x58}
C {devices/ipin.sym} -110 4660 0 0 {name=p58x_bar lab=x58_bar}
C {devices/ipin.sym} -110 4680 0 0 {name=p58k lab=k58}
C {devices/ipin.sym} -110 4700 0 0 {name=p58k_bar lab=k58_bar}
C {devices/ipin.sym} -110 4720 0 0 {name=p59x lab=x59}
C {devices/ipin.sym} -110 4740 0 0 {name=p59x_bar lab=x59_bar}
C {devices/ipin.sym} -110 4760 0 0 {name=p59k lab=k59}
C {devices/ipin.sym} -110 4780 0 0 {name=p59k_bar lab=k59_bar}
C {devices/ipin.sym} -110 4800 0 0 {name=p60x lab=x60}
C {devices/ipin.sym} -110 4820 0 0 {name=p60x_bar lab=x60_bar}
C {devices/ipin.sym} -110 4840 0 0 {name=p60k lab=k60}
C {devices/ipin.sym} -110 4860 0 0 {name=p60k_bar lab=k60_bar}
C {devices/ipin.sym} -110 4880 0 0 {name=p61x lab=x61}
C {devices/ipin.sym} -110 4900 0 0 {name=p61x_bar lab=x61_bar}
C {devices/ipin.sym} -110 4920 0 0 {name=p61k lab=k61}
C {devices/ipin.sym} -110 4940 0 0 {name=p61k_bar lab=k61_bar}
C {devices/ipin.sym} -110 4960 0 0 {name=p62x lab=x62}
C {devices/ipin.sym} -110 4980 0 0 {name=p62x_bar lab=x62_bar}
C {devices/ipin.sym} -110 5000 0 0 {name=p62k lab=k62}
C {devices/ipin.sym} -110 5020 0 0 {name=p62k_bar lab=k62_bar}
C {devices/ipin.sym} -110 5040 0 0 {name=p63x lab=x63}
C {devices/ipin.sym} -110 5060 0 0 {name=p63x_bar lab=x63_bar}
C {devices/ipin.sym} -110 5080 0 0 {name=p63k lab=k63}
C {devices/ipin.sym} -110 5100 0 0 {name=p63k_bar lab=k63_bar}
C {devices/opin.sym} 100 0 0 0 {name=p0s lab=s0}
C {devices/opin.sym} 100 20 0 0 {name=p1s lab=s1}
C {devices/opin.sym} 100 40 0 0 {name=p2s lab=s2}
C {devices/opin.sym} 100 60 0 0 {name=p3s lab=s3}
C {devices/opin.sym} 100 80 0 0 {name=p4s lab=s4}
C {devices/opin.sym} 100 100 0 0 {name=p5s lab=s5}
C {devices/opin.sym} 100 120 0 0 {name=p6s lab=s6}
C {devices/opin.sym} 100 140 0 0 {name=p7s lab=s7}
C {devices/opin.sym} 100 160 0 0 {name=p8s lab=s8}
C {devices/opin.sym} 100 180 0 0 {name=p9s lab=s9}
C {devices/opin.sym} 100 200 0 0 {name=p10s lab=s10}
C {devices/opin.sym} 100 220 0 0 {name=p11s lab=s11}
C {devices/opin.sym} 100 240 0 0 {name=p12s lab=s12}
C {devices/opin.sym} 100 260 0 0 {name=p13s lab=s13}
C {devices/opin.sym} 100 280 0 0 {name=p14s lab=s14}
C {devices/opin.sym} 100 300 0 0 {name=p15s lab=s15}
C {devices/opin.sym} 100 320 0 0 {name=p16s lab=s16}
C {devices/opin.sym} 100 340 0 0 {name=p17s lab=s17}
C {devices/opin.sym} 100 360 0 0 {name=p18s lab=s18}
C {devices/opin.sym} 100 380 0 0 {name=p19s lab=s19}
C {devices/opin.sym} 100 400 0 0 {name=p20s lab=s20}
C {devices/opin.sym} 100 420 0 0 {name=p21s lab=s21}
C {devices/opin.sym} 100 440 0 0 {name=p22s lab=s22}
C {devices/opin.sym} 100 460 0 0 {name=p23s lab=s23}
C {devices/opin.sym} 100 480 0 0 {name=p24s lab=s24}
C {devices/opin.sym} 100 500 0 0 {name=p25s lab=s25}
C {devices/opin.sym} 100 520 0 0 {name=p26s lab=s26}
C {devices/opin.sym} 100 540 0 0 {name=p27s lab=s27}
C {devices/opin.sym} 100 560 0 0 {name=p28s lab=s28}
C {devices/opin.sym} 100 580 0 0 {name=p29s lab=s29}
C {devices/opin.sym} 100 600 0 0 {name=p30s lab=s30}
C {devices/opin.sym} 100 620 0 0 {name=p31s lab=s31}
C {devices/opin.sym} 100 640 0 0 {name=p32s lab=s32}
C {devices/opin.sym} 100 660 0 0 {name=p33s lab=s33}
C {devices/opin.sym} 100 680 0 0 {name=p34s lab=s34}
C {devices/opin.sym} 100 700 0 0 {name=p35s lab=s35}
C {devices/opin.sym} 100 720 0 0 {name=p36s lab=s36}
C {devices/opin.sym} 100 740 0 0 {name=p37s lab=s37}
C {devices/opin.sym} 100 760 0 0 {name=p38s lab=s38}
C {devices/opin.sym} 100 780 0 0 {name=p39s lab=s39}
C {devices/opin.sym} 100 800 0 0 {name=p40s lab=s40}
C {devices/opin.sym} 100 820 0 0 {name=p41s lab=s41}
C {devices/opin.sym} 100 840 0 0 {name=p42s lab=s42}
C {devices/opin.sym} 100 860 0 0 {name=p43s lab=s43}
C {devices/opin.sym} 100 880 0 0 {name=p44s lab=s44}
C {devices/opin.sym} 100 900 0 0 {name=p45s lab=s45}
C {devices/opin.sym} 100 920 0 0 {name=p46s lab=s46}
C {devices/opin.sym} 100 940 0 0 {name=p47s lab=s47}
C {devices/opin.sym} 100 960 0 0 {name=p48s lab=s48}
C {devices/opin.sym} 100 980 0 0 {name=p49s lab=s49}
C {devices/opin.sym} 100 1000 0 0 {name=p50s lab=s50}
C {devices/opin.sym} 100 1020 0 0 {name=p51s lab=s51}
C {devices/opin.sym} 100 1040 0 0 {name=p52s lab=s52}
C {devices/opin.sym} 100 1060 0 0 {name=p53s lab=s53}
C {devices/opin.sym} 100 1080 0 0 {name=p54s lab=s54}
C {devices/opin.sym} 100 1100 0 0 {name=p55s lab=s55}
C {devices/opin.sym} 100 1120 0 0 {name=p56s lab=s56}
C {devices/opin.sym} 100 1140 0 0 {name=p57s lab=s57}
C {devices/opin.sym} 100 1160 0 0 {name=p58s lab=s58}
C {devices/opin.sym} 100 1180 0 0 {name=p59s lab=s59}
C {devices/opin.sym} 100 1200 0 0 {name=p60s lab=s60}
C {devices/opin.sym} 100 1220 0 0 {name=p61s lab=s61}
C {devices/opin.sym} 100 1240 0 0 {name=p62s lab=s62}
C {devices/opin.sym} 100 1260 0 0 {name=p63s lab=s63}
C {devices/opin.sym} 390 -0 0 0 {name=p1 lab=s8}
C {devices/opin.sym} 390 20 0 0 {name=p2 lab=s9}
C {devices/opin.sym} 390 40 0 0 {name=p3 lab=s10}
C {devices/opin.sym} 390 60 0 0 {name=p4 lab=s11}
C {devices/opin.sym} 390 390 0 0 {name=p5 lab=s12}
C {devices/opin.sym} 390 410 0 0 {name=p6 lab=s13}
C {devices/opin.sym} 390 430 0 0 {name=p7 lab=s14}
C {devices/opin.sym} 390 450 0 0 {name=p8 lab=s15}
C {devices/opin.sym} 390 770 0 0 {name=p9 lab=s16}
C {devices/opin.sym} 390 790 0 0 {name=p10 lab=s17}
C {devices/opin.sym} 390 810 0 0 {name=p11 lab=s18}
C {devices/opin.sym} 390 830 0 0 {name=p12 lab=s19}
C {devices/opin.sym} 390 1160 0 0 {name=p13 lab=s20}
C {devices/opin.sym} 390 1180 0 0 {name=p14 lab=s21}
C {devices/opin.sym} 390 1200 0 0 {name=p15 lab=s22}
C {devices/opin.sym} 390 1220 0 0 {name=p16 lab=s23}
C {devices/opin.sym} 390 1540 0 0 {name=p17 lab=s24}
C {devices/opin.sym} 390 1560 0 0 {name=p18 lab=s25}
C {devices/opin.sym} 390 1580 0 0 {name=p19 lab=s26}
C {devices/opin.sym} 390 1600 0 0 {name=p20 lab=s27}
C {devices/opin.sym} 390 1930 0 0 {name=p21 lab=s28}
C {devices/opin.sym} 390 1950 0 0 {name=p22 lab=s29}
C {devices/opin.sym} 390 1970 0 0 {name=p23 lab=s30}
C {devices/opin.sym} 390 1990 0 0 {name=p24 lab=s31}
C {devices/opin.sym} 390 2310 0 0 {name=p25 lab=s32}
C {devices/opin.sym} 390 2330 0 0 {name=p26 lab=s33}
C {devices/opin.sym} 390 2350 0 0 {name=p27 lab=s34}
C {devices/opin.sym} 390 2370 0 0 {name=p28 lab=s35}
C {devices/opin.sym} 390 2700 0 0 {name=p29 lab=s36}
C {devices/opin.sym} 390 2720 0 0 {name=p30 lab=s37}
C {devices/opin.sym} 390 2740 0 0 {name=p31 lab=s38}
C {devices/opin.sym} 390 2760 0 0 {name=p32 lab=s39}
C {devices/opin.sym} 390 3080 0 0 {name=p33 lab=s40}
C {devices/opin.sym} 390 3100 0 0 {name=p34 lab=s41}
C {devices/opin.sym} 390 3120 0 0 {name=p35 lab=s42}
C {devices/opin.sym} 390 3140 0 0 {name=p36 lab=s43}
C {devices/opin.sym} 390 3470 0 0 {name=p37 lab=s44}
C {devices/opin.sym} 390 3490 0 0 {name=p38 lab=s45}
C {devices/opin.sym} 390 3510 0 0 {name=p39 lab=s46}
C {devices/opin.sym} 390 3530 0 0 {name=p40 lab=s47}
C {devices/opin.sym} 390 3850 0 0 {name=p41 lab=s48}
C {devices/opin.sym} 390 3870 0 0 {name=p42 lab=s49}
C {devices/opin.sym} 390 3890 0 0 {name=p43 lab=s50}
C {devices/opin.sym} 390 3910 0 0 {name=p44 lab=s51}
C {devices/opin.sym} 390 4240 0 0 {name=p45 lab=s52}
C {devices/opin.sym} 390 4260 0 0 {name=p46 lab=s53}
C {devices/opin.sym} 390 4280 0 0 {name=p47 lab=s54}
C {devices/opin.sym} 390 4300 0 0 {name=p48 lab=s55}
C {devices/opin.sym} 390 4620 0 0 {name=p49 lab=s56}
C {devices/opin.sym} 390 4640 0 0 {name=p50 lab=s57}
C {devices/opin.sym} 390 4660 0 0 {name=p51 lab=s58}
C {devices/opin.sym} 390 4680 0 0 {name=p52 lab=s59}
C {devices/opin.sym} 390 5010 0 0 {name=p53 lab=s60}
C {devices/opin.sym} 390 5030 0 0 {name=p54 lab=s61}
C {devices/opin.sym} 390 5050 0 0 {name=p55 lab=s62}
C {devices/opin.sym} 390 5070 0 0 {name=p56 lab=s63}
